v {xschem version=3.4.8RC file_version=1.2}
G {}
K {}
V {}
S {}
E {}
N -70 -370 110 -370 {
lab=#net1}
N -70 -400 -40 -400 {
lab=GND}
N -40 -400 -40 -350 {
lab=GND}
N 80 -400 110 -400 {
lab=GND}
N 80 -400 80 -350 {
lab=GND}
N -70 -460 -70 -430 {
lab=#net2}
N 110 -470 110 -430 {
lab=#net3}
N -40 -250 -40 -230 {
lab=#net4}
N -40 -170 -40 -140 {
lab=GND}
N -170 -400 -110 -400 {
lab=#net5}
N -40 -280 -30 -280 {
lab=GND}
N -30 -280 -30 -150 {
lab=GND}
N -40 -150 -30 -150 {
lab=GND}
N -40 -200 -30 -200 {
lab=GND}
N 100 -250 100 -230 {
lab=#net6}
N 100 -170 100 -140 {
lab=GND}
N 100 -280 110 -280 {
lab=GND}
N 110 -280 110 -150 {
lab=GND}
N 100 -150 110 -150 {
lab=GND}
N 100 -200 110 -200 {
lab=GND}
N -40 -310 100 -310 {
lab=#net1}
N 60 -280 60 -240 {
lab=VBIAS}
N -80 -240 60 -240 {
lab=VBIAS}
N -80 -270 -80 -240 {
lab=VBIAS}
N 60 -200 60 -160 {
lab=VBIAS}
N -80 -160 60 -160 {
lab=VBIAS}
N -80 -200 -80 -160 {
lab=VBIAS}
N 20 -370 20 -310 {
lab=#net1}
N -80 -280 -80 -270 {
lab=VBIAS}
N -100 -280 -80 -280 {
lab=VBIAS}
N -100 -200 -80 -200 {
lab=VBIAS}
N 150 -400 200 -400 {
lab=#net7}
N -250 -400 -170 -400 {
lab=#net5}
N -250 -380 -250 -320 {
lab=#net7}
N -250 -320 200 -320 {
lab=#net7}
N 200 -400 200 -320 {
lab=#net7}
N 690 -370 870 -370 {
lab=#net8}
N 690 -400 720 -400 {
lab=GND}
N 720 -400 720 -350 {
lab=GND}
N 840 -400 870 -400 {
lab=GND}
N 840 -400 840 -350 {
lab=GND}
N 690 -460 690 -430 {
lab=#net9}
N 870 -470 870 -430 {
lab=#net10}
N 720 -250 720 -230 {
lab=#net11}
N 720 -170 720 -140 {
lab=GND}
N 590 -400 650 -400 {
lab=#net12}
N 720 -280 730 -280 {
lab=GND}
N 730 -280 730 -150 {
lab=GND}
N 720 -150 730 -150 {
lab=GND}
N 720 -200 730 -200 {
lab=GND}
N 860 -250 860 -230 {
lab=#net13}
N 860 -170 860 -140 {
lab=GND}
N 860 -280 870 -280 {
lab=GND}
N 870 -280 870 -150 {
lab=GND}
N 860 -150 870 -150 {
lab=GND}
N 860 -200 870 -200 {
lab=GND}
N 720 -310 860 -310 {
lab=#net8}
N 820 -280 820 -240 {
lab=VBIAS}
N 680 -240 820 -240 {
lab=VBIAS}
N 680 -270 680 -240 {
lab=VBIAS}
N 820 -200 820 -160 {
lab=VBIAS}
N 680 -160 820 -160 {
lab=VBIAS}
N 680 -200 680 -160 {
lab=VBIAS}
N 780 -370 780 -310 {
lab=#net8}
N 680 -280 680 -270 {
lab=VBIAS}
N 660 -280 680 -280 {
lab=VBIAS}
N 660 -200 680 -200 {
lab=VBIAS}
N 910 -400 960 -400 {
lab=#net14}
N 510 -400 590 -400 {
lab=#net12}
N 510 -380 510 -320 {
lab=#net14}
N 510 -320 960 -320 {
lab=#net14}
N 960 -400 960 -320 {
lab=#net14}
N 1390 -370 1570 -370 {
lab=#net15}
N 1390 -400 1420 -400 {
lab=GND}
N 1420 -400 1420 -350 {
lab=GND}
N 1540 -400 1570 -400 {
lab=GND}
N 1540 -400 1540 -350 {
lab=GND}
N 1390 -460 1390 -430 {
lab=#net16}
N 1570 -470 1570 -430 {
lab=#net17}
N 1420 -250 1420 -230 {
lab=#net18}
N 1420 -170 1420 -140 {
lab=GND}
N 1290 -400 1350 -400 {
lab=#net19}
N 1420 -280 1430 -280 {
lab=GND}
N 1430 -280 1430 -150 {
lab=GND}
N 1420 -150 1430 -150 {
lab=GND}
N 1420 -200 1430 -200 {
lab=GND}
N 1560 -250 1560 -230 {
lab=#net20}
N 1560 -170 1560 -140 {
lab=GND}
N 1560 -280 1570 -280 {
lab=GND}
N 1570 -280 1570 -150 {
lab=GND}
N 1560 -150 1570 -150 {
lab=GND}
N 1560 -200 1570 -200 {
lab=GND}
N 1420 -310 1560 -310 {
lab=#net15}
N 1520 -280 1520 -240 {
lab=VBIAS}
N 1380 -240 1520 -240 {
lab=VBIAS}
N 1380 -270 1380 -240 {
lab=VBIAS}
N 1520 -200 1520 -160 {
lab=VBIAS}
N 1380 -160 1520 -160 {
lab=VBIAS}
N 1380 -200 1380 -160 {
lab=VBIAS}
N 1480 -370 1480 -310 {
lab=#net15}
N 1380 -280 1380 -270 {
lab=VBIAS}
N 1360 -280 1380 -280 {
lab=VBIAS}
N 1360 -200 1380 -200 {
lab=VBIAS}
N 1610 -400 1660 -400 {
lab=#net21}
N 1210 -400 1290 -400 {
lab=#net19}
N 1210 -380 1210 -320 {
lab=#net21}
N 1210 -320 1660 -320 {
lab=#net21}
N 1660 -400 1660 -320 {
lab=#net21}
N 2120 -370 2300 -370 {
lab=#net22}
N 2120 -400 2150 -400 {
lab=GND}
N 2150 -400 2150 -350 {
lab=GND}
N 2270 -400 2300 -400 {
lab=GND}
N 2270 -400 2270 -350 {
lab=GND}
N 2120 -460 2120 -430 {
lab=#net23}
N 2300 -470 2300 -430 {
lab=#net24}
N 2150 -250 2150 -230 {
lab=#net25}
N 2150 -170 2150 -140 {
lab=GND}
N 2020 -400 2080 -400 {
lab=#net26}
N 2150 -280 2160 -280 {
lab=GND}
N 2160 -280 2160 -150 {
lab=GND}
N 2150 -150 2160 -150 {
lab=GND}
N 2150 -200 2160 -200 {
lab=GND}
N 2290 -250 2290 -230 {
lab=#net27}
N 2290 -170 2290 -140 {
lab=GND}
N 2290 -280 2300 -280 {
lab=GND}
N 2300 -280 2300 -150 {
lab=GND}
N 2290 -150 2300 -150 {
lab=GND}
N 2290 -200 2300 -200 {
lab=GND}
N 2150 -310 2290 -310 {
lab=#net22}
N 2250 -280 2250 -240 {
lab=VBIAS}
N 2110 -240 2250 -240 {
lab=VBIAS}
N 2110 -270 2110 -240 {
lab=VBIAS}
N 2250 -200 2250 -160 {
lab=VBIAS}
N 2110 -160 2250 -160 {
lab=VBIAS}
N 2110 -200 2110 -160 {
lab=VBIAS}
N 2210 -370 2210 -310 {
lab=#net22}
N 2110 -280 2110 -270 {
lab=VBIAS}
N 2090 -280 2110 -280 {
lab=VBIAS}
N 2090 -200 2110 -200 {
lab=VBIAS}
N 2340 -400 2390 -400 {
lab=#net28}
N 1940 -400 2020 -400 {
lab=#net26}
N 1940 -380 1940 -320 {
lab=#net28}
N 1940 -320 2390 -320 {
lab=#net28}
N 2390 -400 2390 -320 {
lab=#net28}
N 2840 -370 3020 -370 {
lab=#net29}
N 2840 -400 2870 -400 {
lab=GND}
N 2870 -400 2870 -350 {
lab=GND}
N 2990 -400 3020 -400 {
lab=GND}
N 2990 -400 2990 -350 {
lab=GND}
N 2840 -460 2840 -430 {
lab=#net30}
N 3020 -470 3020 -430 {
lab=#net31}
N 2870 -250 2870 -230 {
lab=#net32}
N 2870 -170 2870 -140 {
lab=GND}
N 2740 -400 2800 -400 {
lab=#net33}
N 2870 -280 2880 -280 {
lab=GND}
N 2880 -280 2880 -150 {
lab=GND}
N 2870 -150 2880 -150 {
lab=GND}
N 2870 -200 2880 -200 {
lab=GND}
N 3010 -250 3010 -230 {
lab=#net34}
N 3010 -170 3010 -140 {
lab=GND}
N 3010 -280 3020 -280 {
lab=GND}
N 3020 -280 3020 -150 {
lab=GND}
N 3010 -150 3020 -150 {
lab=GND}
N 3010 -200 3020 -200 {
lab=GND}
N 2870 -310 3010 -310 {
lab=#net29}
N 2970 -280 2970 -240 {
lab=VBIAS}
N 2830 -240 2970 -240 {
lab=VBIAS}
N 2830 -270 2830 -240 {
lab=VBIAS}
N 2970 -200 2970 -160 {
lab=VBIAS}
N 2830 -160 2970 -160 {
lab=VBIAS}
N 2830 -200 2830 -160 {
lab=VBIAS}
N 2930 -370 2930 -310 {
lab=#net29}
N 2830 -280 2830 -270 {
lab=VBIAS}
N 2810 -280 2830 -280 {
lab=VBIAS}
N 2810 -200 2830 -200 {
lab=VBIAS}
N 3060 -400 3110 -400 {
lab=#net35}
N 2660 -400 2740 -400 {
lab=#net33}
N 2660 -380 2660 -320 {
lab=#net35}
N 2660 -320 3110 -320 {
lab=#net35}
N 3110 -400 3110 -320 {
lab=#net35}
N 3550 -370 3730 -370 {
lab=#net36}
N 3550 -400 3580 -400 {
lab=GND}
N 3580 -400 3580 -350 {
lab=GND}
N 3700 -400 3730 -400 {
lab=GND}
N 3700 -400 3700 -350 {
lab=GND}
N 3550 -460 3550 -430 {
lab=#net37}
N 3730 -470 3730 -430 {
lab=#net38}
N 3580 -250 3580 -230 {
lab=#net39}
N 3580 -170 3580 -140 {
lab=GND}
N 3450 -400 3510 -400 {
lab=#net40}
N 3580 -280 3590 -280 {
lab=GND}
N 3590 -280 3590 -150 {
lab=GND}
N 3580 -150 3590 -150 {
lab=GND}
N 3580 -200 3590 -200 {
lab=GND}
N 3720 -250 3720 -230 {
lab=#net41}
N 3720 -170 3720 -140 {
lab=GND}
N 3720 -280 3730 -280 {
lab=GND}
N 3730 -280 3730 -150 {
lab=GND}
N 3720 -150 3730 -150 {
lab=GND}
N 3720 -200 3730 -200 {
lab=GND}
N 3580 -310 3720 -310 {
lab=#net36}
N 3680 -280 3680 -240 {
lab=VBIAS}
N 3540 -240 3680 -240 {
lab=VBIAS}
N 3540 -270 3540 -240 {
lab=VBIAS}
N 3680 -200 3680 -160 {
lab=VBIAS}
N 3540 -160 3680 -160 {
lab=VBIAS}
N 3540 -200 3540 -160 {
lab=VBIAS}
N 3640 -370 3640 -310 {
lab=#net36}
N 3540 -280 3540 -270 {
lab=VBIAS}
N 3520 -280 3540 -280 {
lab=VBIAS}
N 3520 -200 3540 -200 {
lab=VBIAS}
N 3770 -400 3820 -400 {
lab=#net42}
N 3370 -400 3450 -400 {
lab=#net40}
N 3370 -380 3370 -320 {
lab=#net42}
N 3370 -320 3820 -320 {
lab=#net42}
N 3820 -400 3820 -320 {
lab=#net42}
N 4260 -370 4440 -370 {
lab=#net43}
N 4260 -400 4290 -400 {
lab=GND}
N 4290 -400 4290 -350 {
lab=GND}
N 4410 -400 4440 -400 {
lab=GND}
N 4410 -400 4410 -350 {
lab=GND}
N 4260 -460 4260 -430 {
lab=#net44}
N 4440 -470 4440 -430 {
lab=#net45}
N 4290 -250 4290 -230 {
lab=#net46}
N 4290 -170 4290 -140 {
lab=GND}
N 4160 -400 4220 -400 {
lab=#net47}
N 4290 -280 4300 -280 {
lab=GND}
N 4300 -280 4300 -150 {
lab=GND}
N 4290 -150 4300 -150 {
lab=GND}
N 4290 -200 4300 -200 {
lab=GND}
N 4430 -250 4430 -230 {
lab=#net48}
N 4430 -170 4430 -140 {
lab=GND}
N 4430 -280 4440 -280 {
lab=GND}
N 4440 -280 4440 -150 {
lab=GND}
N 4430 -150 4440 -150 {
lab=GND}
N 4430 -200 4440 -200 {
lab=GND}
N 4290 -310 4430 -310 {
lab=#net43}
N 4390 -280 4390 -240 {
lab=VBIAS}
N 4250 -240 4390 -240 {
lab=VBIAS}
N 4250 -270 4250 -240 {
lab=VBIAS}
N 4390 -200 4390 -160 {
lab=VBIAS}
N 4250 -160 4390 -160 {
lab=VBIAS}
N 4250 -200 4250 -160 {
lab=VBIAS}
N 4350 -370 4350 -310 {
lab=#net43}
N 4250 -280 4250 -270 {
lab=VBIAS}
N 4230 -280 4250 -280 {
lab=VBIAS}
N 4230 -200 4250 -200 {
lab=VBIAS}
N 4480 -400 4530 -400 {
lab=#net49}
N 4080 -400 4160 -400 {
lab=#net47}
N 4080 -380 4080 -320 {
lab=#net49}
N 4080 -320 4530 -320 {
lab=#net49}
N 4530 -400 4530 -320 {
lab=#net49}
N 4960 -370 5140 -370 {
lab=#net50}
N 4960 -400 4990 -400 {
lab=GND}
N 4990 -400 4990 -350 {
lab=GND}
N 5110 -400 5140 -400 {
lab=GND}
N 5110 -400 5110 -350 {
lab=GND}
N 4960 -460 4960 -430 {
lab=#net51}
N 5140 -470 5140 -430 {
lab=#net52}
N 4990 -250 4990 -230 {
lab=#net53}
N 4990 -170 4990 -140 {
lab=GND}
N 4860 -400 4920 -400 {
lab=#net54}
N 4990 -280 5000 -280 {
lab=GND}
N 5000 -280 5000 -150 {
lab=GND}
N 4990 -150 5000 -150 {
lab=GND}
N 4990 -200 5000 -200 {
lab=GND}
N 5130 -250 5130 -230 {
lab=#net55}
N 5130 -170 5130 -140 {
lab=GND}
N 5130 -280 5140 -280 {
lab=GND}
N 5140 -280 5140 -150 {
lab=GND}
N 5130 -150 5140 -150 {
lab=GND}
N 5130 -200 5140 -200 {
lab=GND}
N 4990 -310 5130 -310 {
lab=#net50}
N 5090 -280 5090 -240 {
lab=VBIAS}
N 4950 -240 5090 -240 {
lab=VBIAS}
N 4950 -270 4950 -240 {
lab=VBIAS}
N 5090 -200 5090 -160 {
lab=VBIAS}
N 4950 -160 5090 -160 {
lab=VBIAS}
N 4950 -200 4950 -160 {
lab=VBIAS}
N 5050 -370 5050 -310 {
lab=#net50}
N 4950 -280 4950 -270 {
lab=VBIAS}
N 4930 -280 4950 -280 {
lab=VBIAS}
N 4930 -200 4950 -200 {
lab=VBIAS}
N 5180 -400 5230 -400 {
lab=#net56}
N 4780 -400 4860 -400 {
lab=#net54}
N 4780 -380 4780 -320 {
lab=#net56}
N 4780 -320 5230 -320 {
lab=#net56}
N 5230 -400 5230 -320 {
lab=#net56}
N -70 90 110 90 {
lab=#net57}
N -70 60 -40 60 {
lab=GND}
N -40 60 -40 110 {
lab=GND}
N 80 60 110 60 {
lab=GND}
N 80 60 80 110 {
lab=GND}
N -70 0 -70 30 {
lab=#net58}
N 110 -10 110 30 {
lab=#net59}
N -40 210 -40 230 {
lab=#net60}
N -40 290 -40 310 {
lab=GND}
N -170 60 -110 60 {
lab=#net61}
N -40 180 -30 180 {
lab=GND}
N -30 180 -30 310 {
lab=GND}
N -40 310 -30 310 {
lab=GND}
N -40 260 -30 260 {
lab=GND}
N 100 210 100 230 {
lab=#net62}
N 100 290 100 310 {
lab=GND}
N 100 180 110 180 {
lab=GND}
N 110 180 110 310 {
lab=GND}
N 100 310 110 310 {
lab=GND}
N 100 260 110 260 {
lab=GND}
N -40 150 100 150 {
lab=#net57}
N 60 180 60 220 {
lab=VBIAS}
N -80 220 60 220 {
lab=VBIAS}
N -80 190 -80 220 {
lab=VBIAS}
N 60 260 60 300 {
lab=VBIAS}
N -80 300 60 300 {
lab=VBIAS}
N -80 260 -80 300 {
lab=VBIAS}
N 20 90 20 150 {
lab=#net57}
N -80 180 -80 190 {
lab=VBIAS}
N -100 180 -80 180 {
lab=VBIAS}
N -100 260 -80 260 {
lab=VBIAS}
N 150 60 200 60 {
lab=#net63}
N -250 60 -170 60 {
lab=#net61}
N -250 80 -250 140 {
lab=#net63}
N -250 140 200 140 {
lab=#net63}
N 200 60 200 140 {
lab=#net63}
N 690 90 870 90 {
lab=#net64}
N 690 60 720 60 {
lab=GND}
N 720 60 720 110 {
lab=GND}
N 840 60 870 60 {
lab=GND}
N 840 60 840 110 {
lab=GND}
N 690 0 690 30 {
lab=#net65}
N 870 0 870 30 {
lab=#net66}
N 720 210 720 230 {
lab=#net67}
N 720 290 720 310 {
lab=GND}
N 590 60 650 60 {
lab=#net68}
N 720 180 730 180 {
lab=GND}
N 730 180 730 310 {
lab=GND}
N 720 310 730 310 {
lab=GND}
N 720 260 730 260 {
lab=GND}
N 860 210 860 230 {
lab=#net69}
N 860 290 860 320 {
lab=GND}
N 860 180 870 180 {
lab=GND}
N 870 180 870 310 {
lab=GND}
N 860 310 870 310 {
lab=GND}
N 860 260 870 260 {
lab=GND}
N 720 150 860 150 {
lab=#net64}
N 820 180 820 220 {
lab=VBIAS}
N 680 220 820 220 {
lab=VBIAS}
N 680 190 680 220 {
lab=VBIAS}
N 820 260 820 300 {
lab=VBIAS}
N 680 300 820 300 {
lab=VBIAS}
N 680 260 680 300 {
lab=VBIAS}
N 780 90 780 150 {
lab=#net64}
N 680 180 680 190 {
lab=VBIAS}
N 660 180 680 180 {
lab=VBIAS}
N 660 260 680 260 {
lab=VBIAS}
N 910 60 960 60 {
lab=#net70}
N 510 60 590 60 {
lab=#net68}
N 510 80 510 140 {
lab=#net70}
N 510 140 960 140 {
lab=#net70}
N 960 60 960 140 {
lab=#net70}
N 1390 90 1570 90 {
lab=#net71}
N 1390 60 1420 60 {
lab=GND}
N 1420 60 1420 110 {
lab=GND}
N 1540 60 1570 60 {
lab=GND}
N 1540 60 1540 110 {
lab=GND}
N 1390 0 1390 30 {
lab=#net72}
N 1570 0 1570 30 {
lab=#net73}
N 1420 210 1420 230 {
lab=#net74}
N 1420 290 1420 320 {
lab=GND}
N 1290 60 1350 60 {
lab=#net75}
N 1420 180 1430 180 {
lab=GND}
N 1430 180 1430 310 {
lab=GND}
N 1420 310 1430 310 {
lab=GND}
N 1420 260 1430 260 {
lab=GND}
N 1560 210 1560 230 {
lab=#net76}
N 1560 290 1560 320 {
lab=GND}
N 1560 180 1570 180 {
lab=GND}
N 1570 180 1570 310 {
lab=GND}
N 1560 310 1570 310 {
lab=GND}
N 1560 260 1570 260 {
lab=GND}
N 1420 150 1560 150 {
lab=#net71}
N 1520 180 1520 220 {
lab=VBIAS}
N 1380 220 1520 220 {
lab=VBIAS}
N 1380 190 1380 220 {
lab=VBIAS}
N 1520 260 1520 300 {
lab=VBIAS}
N 1380 300 1520 300 {
lab=VBIAS}
N 1380 260 1380 300 {
lab=VBIAS}
N 1480 90 1480 150 {
lab=#net71}
N 1380 180 1380 190 {
lab=VBIAS}
N 1360 180 1380 180 {
lab=VBIAS}
N 1360 260 1380 260 {
lab=VBIAS}
N 1610 60 1660 60 {
lab=#net77}
N 1210 60 1290 60 {
lab=#net75}
N 1210 80 1210 140 {
lab=#net77}
N 1210 140 1660 140 {
lab=#net77}
N 1660 60 1660 140 {
lab=#net77}
N 2120 90 2300 90 {
lab=#net78}
N 2120 60 2150 60 {
lab=GND}
N 2150 60 2150 110 {
lab=GND}
N 2270 60 2300 60 {
lab=GND}
N 2270 60 2270 110 {
lab=GND}
N 2120 0 2120 30 {
lab=#net79}
N 2300 10 2300 30 {
lab=#net80}
N 2150 210 2150 230 {
lab=#net81}
N 2150 290 2150 320 {
lab=GND}
N 2020 60 2080 60 {
lab=#net82}
N 2150 180 2160 180 {
lab=GND}
N 2160 180 2160 310 {
lab=GND}
N 2150 310 2160 310 {
lab=GND}
N 2150 260 2160 260 {
lab=GND}
N 2290 210 2290 230 {
lab=#net83}
N 2290 290 2290 320 {
lab=GND}
N 2290 180 2300 180 {
lab=GND}
N 2300 180 2300 310 {
lab=GND}
N 2290 310 2300 310 {
lab=GND}
N 2290 260 2300 260 {
lab=GND}
N 2150 150 2290 150 {
lab=#net78}
N 2250 180 2250 220 {
lab=VBIAS}
N 2110 220 2250 220 {
lab=VBIAS}
N 2110 190 2110 220 {
lab=VBIAS}
N 2250 260 2250 300 {
lab=VBIAS}
N 2110 300 2250 300 {
lab=VBIAS}
N 2110 260 2110 300 {
lab=VBIAS}
N 2210 90 2210 150 {
lab=#net78}
N 2110 180 2110 190 {
lab=VBIAS}
N 2090 180 2110 180 {
lab=VBIAS}
N 2090 260 2110 260 {
lab=VBIAS}
N 2340 60 2390 60 {
lab=#net84}
N 1940 60 2020 60 {
lab=#net82}
N 1940 80 1940 140 {
lab=#net84}
N 1940 140 2390 140 {
lab=#net84}
N 2390 60 2390 140 {
lab=#net84}
N 2840 90 3020 90 {
lab=#net85}
N 2840 60 2870 60 {
lab=GND}
N 2870 60 2870 110 {
lab=GND}
N 2990 60 3020 60 {
lab=GND}
N 2990 60 2990 110 {
lab=GND}
N 2840 0 2840 30 {
lab=#net86}
N 3020 0 3020 30 {
lab=#net87}
N 2870 210 2870 230 {
lab=#net88}
N 2870 290 2870 320 {
lab=GND}
N 2740 60 2800 60 {
lab=#net89}
N 2870 180 2880 180 {
lab=GND}
N 2880 180 2880 310 {
lab=GND}
N 2870 310 2880 310 {
lab=GND}
N 2870 260 2880 260 {
lab=GND}
N 3010 210 3010 230 {
lab=#net90}
N 3010 290 3010 320 {
lab=GND}
N 3010 180 3020 180 {
lab=GND}
N 3020 180 3020 310 {
lab=GND}
N 3010 310 3020 310 {
lab=GND}
N 3010 260 3020 260 {
lab=GND}
N 2870 150 3010 150 {
lab=#net85}
N 2970 180 2970 220 {
lab=VBIAS}
N 2830 220 2970 220 {
lab=VBIAS}
N 2830 190 2830 220 {
lab=VBIAS}
N 2970 260 2970 300 {
lab=VBIAS}
N 2830 300 2970 300 {
lab=VBIAS}
N 2830 260 2830 300 {
lab=VBIAS}
N 2930 90 2930 150 {
lab=#net85}
N 2830 180 2830 190 {
lab=VBIAS}
N 2810 180 2830 180 {
lab=VBIAS}
N 2810 260 2830 260 {
lab=VBIAS}
N 3060 60 3110 60 {
lab=#net91}
N 2660 60 2740 60 {
lab=#net89}
N 2660 80 2660 140 {
lab=#net91}
N 2660 140 3110 140 {
lab=#net91}
N 3110 60 3110 140 {
lab=#net91}
N 3550 90 3730 90 {
lab=#net92}
N 3550 60 3580 60 {
lab=GND}
N 3580 60 3580 110 {
lab=GND}
N 3700 60 3730 60 {
lab=GND}
N 3700 60 3700 110 {
lab=GND}
N 3550 10 3550 30 {
lab=#net93}
N 3730 0 3730 30 {
lab=#net94}
N 3580 210 3580 230 {
lab=#net95}
N 3580 290 3580 320 {
lab=GND}
N 3450 60 3510 60 {
lab=#net96}
N 3580 180 3590 180 {
lab=GND}
N 3590 180 3590 310 {
lab=GND}
N 3580 310 3590 310 {
lab=GND}
N 3580 260 3590 260 {
lab=GND}
N 3720 210 3720 230 {
lab=#net97}
N 3720 290 3720 320 {
lab=GND}
N 3720 180 3730 180 {
lab=GND}
N 3730 180 3730 310 {
lab=GND}
N 3720 310 3730 310 {
lab=GND}
N 3720 260 3730 260 {
lab=GND}
N 3580 150 3720 150 {
lab=#net92}
N 3680 180 3680 220 {
lab=VBIAS}
N 3540 220 3680 220 {
lab=VBIAS}
N 3540 190 3540 220 {
lab=VBIAS}
N 3680 260 3680 300 {
lab=VBIAS}
N 3540 300 3680 300 {
lab=VBIAS}
N 3540 260 3540 300 {
lab=VBIAS}
N 3640 90 3640 150 {
lab=#net92}
N 3540 180 3540 190 {
lab=VBIAS}
N 3520 180 3540 180 {
lab=VBIAS}
N 3520 260 3540 260 {
lab=VBIAS}
N 3770 60 3820 60 {
lab=#net98}
N 3370 60 3450 60 {
lab=#net96}
N 3370 80 3370 140 {
lab=#net98}
N 3370 140 3820 140 {
lab=#net98}
N 3820 60 3820 140 {
lab=#net98}
N 4260 90 4440 90 {
lab=#net99}
N 4260 60 4290 60 {
lab=GND}
N 4290 60 4290 110 {
lab=GND}
N 4410 60 4440 60 {
lab=GND}
N 4410 60 4410 110 {
lab=GND}
N 4260 10 4260 30 {
lab=#net100}
N 4440 10 4440 30 {
lab=#net101}
N 4290 210 4290 230 {
lab=#net102}
N 4290 290 4290 320 {
lab=GND}
N 4160 60 4220 60 {
lab=#net103}
N 4290 180 4300 180 {
lab=GND}
N 4300 180 4300 310 {
lab=GND}
N 4290 310 4300 310 {
lab=GND}
N 4290 260 4300 260 {
lab=GND}
N 4430 210 4430 230 {
lab=#net104}
N 4430 290 4430 320 {
lab=GND}
N 4430 180 4440 180 {
lab=GND}
N 4440 180 4440 310 {
lab=GND}
N 4430 310 4440 310 {
lab=GND}
N 4430 260 4440 260 {
lab=GND}
N 4290 150 4430 150 {
lab=#net99}
N 4390 180 4390 220 {
lab=VBIAS}
N 4250 220 4390 220 {
lab=VBIAS}
N 4250 190 4250 220 {
lab=VBIAS}
N 4390 260 4390 300 {
lab=VBIAS}
N 4250 300 4390 300 {
lab=VBIAS}
N 4250 260 4250 300 {
lab=VBIAS}
N 4350 90 4350 150 {
lab=#net99}
N 4250 180 4250 190 {
lab=VBIAS}
N 4230 180 4250 180 {
lab=VBIAS}
N 4230 260 4250 260 {
lab=VBIAS}
N 4480 60 4530 60 {
lab=#net105}
N 4080 60 4160 60 {
lab=#net103}
N 4080 80 4080 140 {
lab=#net105}
N 4080 140 4530 140 {
lab=#net105}
N 4530 60 4530 140 {
lab=#net105}
N 4960 110 5140 110 {
lab=#net106}
N 4960 80 4990 80 {
lab=GND}
N 4990 80 4990 130 {
lab=GND}
N 5110 80 5140 80 {
lab=GND}
N 5110 80 5110 130 {
lab=GND}
N 4960 20 4960 50 {
lab=#net107}
N 5140 10 5140 50 {
lab=#net108}
N 4990 230 4990 250 {
lab=#net109}
N 4860 80 4920 80 {
lab=#net110}
N 4990 200 5000 200 {
lab=GND}
N 5000 200 5000 330 {
lab=GND}
N 4990 330 5000 330 {
lab=GND}
N 4990 280 5000 280 {
lab=GND}
N 5130 230 5130 250 {
lab=#net111}
N 5130 310 5130 340 {
lab=GND}
N 5130 200 5140 200 {
lab=GND}
N 5140 200 5140 330 {
lab=GND}
N 5130 330 5140 330 {
lab=GND}
N 5130 280 5140 280 {
lab=GND}
N 4990 170 5130 170 {
lab=#net106}
N 5090 200 5090 240 {
lab=VBIAS}
N 4950 240 5090 240 {
lab=VBIAS}
N 4950 210 4950 240 {
lab=VBIAS}
N 5090 280 5090 320 {
lab=VBIAS}
N 4950 320 5090 320 {
lab=VBIAS}
N 4950 280 4950 320 {
lab=VBIAS}
N 5050 110 5050 170 {
lab=#net106}
N 4950 200 4950 210 {
lab=VBIAS}
N 4930 200 4950 200 {
lab=VBIAS}
N 4930 280 4950 280 {
lab=VBIAS}
N 5180 80 5230 80 {
lab=#net112}
N 4780 80 4860 80 {
lab=#net110}
N 4780 100 4780 160 {
lab=#net112}
N 4780 160 5230 160 {
lab=#net112}
N 5230 80 5230 160 {
lab=#net112}
N -70 540 110 540 {
lab=#net113}
N -70 510 -40 510 {
lab=GND}
N -40 510 -40 560 {
lab=GND}
N 80 510 110 510 {
lab=GND}
N 80 510 80 560 {
lab=GND}
N -70 450 -70 480 {
lab=#net114}
N 110 440 110 480 {
lab=#net115}
N -40 660 -40 680 {
lab=#net116}
N -40 740 -40 770 {
lab=GND}
N -170 510 -110 510 {
lab=#net117}
N -40 630 -30 630 {
lab=GND}
N -30 630 -30 760 {
lab=GND}
N -40 760 -30 760 {
lab=GND}
N -40 710 -30 710 {
lab=GND}
N 100 660 100 680 {
lab=#net118}
N 100 740 100 770 {
lab=GND}
N 100 630 110 630 {
lab=GND}
N 110 630 110 760 {
lab=GND}
N 100 760 110 760 {
lab=GND}
N 100 710 110 710 {
lab=GND}
N -40 600 100 600 {
lab=#net113}
N 60 630 60 670 {
lab=VBIAS}
N -80 670 60 670 {
lab=VBIAS}
N -80 640 -80 670 {
lab=VBIAS}
N 60 710 60 750 {
lab=VBIAS}
N -80 750 60 750 {
lab=VBIAS}
N -80 710 -80 750 {
lab=VBIAS}
N 20 540 20 600 {
lab=#net113}
N -80 630 -80 640 {
lab=VBIAS}
N -100 630 -80 630 {
lab=VBIAS}
N -100 710 -80 710 {
lab=VBIAS}
N 150 510 200 510 {
lab=#net119}
N -250 510 -170 510 {
lab=#net117}
N -250 530 -250 590 {
lab=#net119}
N -250 590 200 590 {
lab=#net119}
N 200 510 200 590 {
lab=#net119}
N 690 540 870 540 {
lab=#net120}
N 690 510 720 510 {
lab=GND}
N 720 510 720 560 {
lab=GND}
N 840 510 870 510 {
lab=GND}
N 840 510 840 560 {
lab=GND}
N 690 450 690 480 {
lab=#net121}
N 870 440 870 480 {
lab=#net122}
N 720 660 720 680 {
lab=#net123}
N 720 740 720 770 {
lab=GND}
N 590 510 650 510 {
lab=#net124}
N 720 630 730 630 {
lab=GND}
N 730 630 730 760 {
lab=GND}
N 720 760 730 760 {
lab=GND}
N 720 710 730 710 {
lab=GND}
N 860 660 860 680 {
lab=#net125}
N 860 740 860 770 {
lab=GND}
N 860 630 870 630 {
lab=GND}
N 870 630 870 760 {
lab=GND}
N 860 760 870 760 {
lab=GND}
N 860 710 870 710 {
lab=GND}
N 720 600 860 600 {
lab=#net120}
N 820 630 820 670 {
lab=VBIAS}
N 680 670 820 670 {
lab=VBIAS}
N 680 640 680 670 {
lab=VBIAS}
N 820 710 820 750 {
lab=VBIAS}
N 680 750 820 750 {
lab=VBIAS}
N 680 710 680 750 {
lab=VBIAS}
N 780 540 780 600 {
lab=#net120}
N 680 630 680 640 {
lab=VBIAS}
N 660 630 680 630 {
lab=VBIAS}
N 660 710 680 710 {
lab=VBIAS}
N 910 510 960 510 {
lab=#net126}
N 510 510 590 510 {
lab=#net124}
N 510 530 510 590 {
lab=#net126}
N 510 590 960 590 {
lab=#net126}
N 960 510 960 590 {
lab=#net126}
N 1390 540 1570 540 {
lab=#net127}
N 1390 510 1420 510 {
lab=GND}
N 1420 510 1420 560 {
lab=GND}
N 1540 510 1570 510 {
lab=GND}
N 1540 510 1540 560 {
lab=GND}
N 1390 450 1390 480 {
lab=#net128}
N 1570 440 1570 480 {
lab=#net129}
N 1420 660 1420 680 {
lab=#net130}
N 1420 740 1420 770 {
lab=GND}
N 1290 510 1350 510 {
lab=#net131}
N 1420 630 1430 630 {
lab=GND}
N 1430 630 1430 760 {
lab=GND}
N 1420 760 1430 760 {
lab=GND}
N 1420 710 1430 710 {
lab=GND}
N 1560 660 1560 680 {
lab=#net132}
N 1560 740 1560 770 {
lab=GND}
N 1560 630 1570 630 {
lab=GND}
N 1570 630 1570 760 {
lab=GND}
N 1560 760 1570 760 {
lab=GND}
N 1560 710 1570 710 {
lab=GND}
N 1420 600 1560 600 {
lab=#net127}
N 1520 630 1520 670 {
lab=VBIAS}
N 1380 670 1520 670 {
lab=VBIAS}
N 1380 640 1380 670 {
lab=VBIAS}
N 1520 710 1520 750 {
lab=VBIAS}
N 1380 750 1520 750 {
lab=VBIAS}
N 1380 710 1380 750 {
lab=VBIAS}
N 1480 540 1480 600 {
lab=#net127}
N 1380 630 1380 640 {
lab=VBIAS}
N 1360 630 1380 630 {
lab=VBIAS}
N 1360 710 1380 710 {
lab=VBIAS}
N 1610 510 1660 510 {
lab=#net133}
N 1210 510 1290 510 {
lab=#net131}
N 1210 530 1210 590 {
lab=#net133}
N 1210 590 1660 590 {
lab=#net133}
N 1660 510 1660 590 {
lab=#net133}
N 2120 540 2300 540 {
lab=#net134}
N 2120 510 2150 510 {
lab=GND}
N 2150 510 2150 560 {
lab=GND}
N 2270 510 2300 510 {
lab=GND}
N 2270 510 2270 560 {
lab=GND}
N 2120 450 2120 480 {
lab=#net135}
N 2300 440 2300 480 {
lab=#net136}
N 2150 660 2150 680 {
lab=#net137}
N 2150 740 2150 770 {
lab=GND}
N 2020 510 2080 510 {
lab=#net138}
N 2150 630 2160 630 {
lab=GND}
N 2160 630 2160 760 {
lab=GND}
N 2150 760 2160 760 {
lab=GND}
N 2150 710 2160 710 {
lab=GND}
N 2290 660 2290 680 {
lab=#net139}
N 2290 740 2290 770 {
lab=GND}
N 2290 630 2300 630 {
lab=GND}
N 2300 630 2300 760 {
lab=GND}
N 2290 760 2300 760 {
lab=GND}
N 2290 710 2300 710 {
lab=GND}
N 2150 600 2290 600 {
lab=#net134}
N 2250 630 2250 670 {
lab=VBIAS}
N 2110 670 2250 670 {
lab=VBIAS}
N 2110 640 2110 670 {
lab=VBIAS}
N 2250 710 2250 750 {
lab=VBIAS}
N 2110 750 2250 750 {
lab=VBIAS}
N 2110 710 2110 750 {
lab=VBIAS}
N 2210 540 2210 600 {
lab=#net134}
N 2110 630 2110 640 {
lab=VBIAS}
N 2090 630 2110 630 {
lab=VBIAS}
N 2090 710 2110 710 {
lab=VBIAS}
N 2340 510 2390 510 {
lab=#net140}
N 1940 510 2020 510 {
lab=#net138}
N 1940 530 1940 590 {
lab=#net140}
N 1940 590 2390 590 {
lab=#net140}
N 2390 510 2390 590 {
lab=#net140}
N 2840 540 3020 540 {
lab=#net141}
N 2840 510 2870 510 {
lab=GND}
N 2870 510 2870 560 {
lab=GND}
N 2990 510 3020 510 {
lab=GND}
N 2990 510 2990 560 {
lab=GND}
N 2840 450 2840 480 {
lab=#net142}
N 3020 440 3020 480 {
lab=#net143}
N 2870 660 2870 680 {
lab=#net144}
N 2870 740 2870 770 {
lab=GND}
N 2740 510 2800 510 {
lab=#net145}
N 2870 630 2880 630 {
lab=GND}
N 2880 630 2880 760 {
lab=GND}
N 2870 760 2880 760 {
lab=GND}
N 2870 710 2880 710 {
lab=GND}
N 3010 660 3010 680 {
lab=#net146}
N 3010 740 3010 770 {
lab=GND}
N 3010 630 3020 630 {
lab=GND}
N 3020 630 3020 760 {
lab=GND}
N 3010 760 3020 760 {
lab=GND}
N 3010 710 3020 710 {
lab=GND}
N 2870 600 3010 600 {
lab=#net141}
N 2970 630 2970 670 {
lab=VBIAS}
N 2830 670 2970 670 {
lab=VBIAS}
N 2830 640 2830 670 {
lab=VBIAS}
N 2970 710 2970 750 {
lab=VBIAS}
N 2830 750 2970 750 {
lab=VBIAS}
N 2830 710 2830 750 {
lab=VBIAS}
N 2930 540 2930 600 {
lab=#net141}
N 2830 630 2830 640 {
lab=VBIAS}
N 2810 630 2830 630 {
lab=VBIAS}
N 2810 710 2830 710 {
lab=VBIAS}
N 3060 510 3110 510 {
lab=#net147}
N 2660 510 2740 510 {
lab=#net145}
N 2660 530 2660 590 {
lab=#net147}
N 2660 590 3110 590 {
lab=#net147}
N 3110 510 3110 590 {
lab=#net147}
N 3550 540 3730 540 {
lab=#net148}
N 3550 510 3580 510 {
lab=GND}
N 3580 510 3580 560 {
lab=GND}
N 3700 510 3730 510 {
lab=GND}
N 3700 510 3700 560 {
lab=GND}
N 3550 450 3550 480 {
lab=#net149}
N 3730 440 3730 480 {
lab=#net150}
N 3580 660 3580 680 {
lab=#net151}
N 3580 740 3580 770 {
lab=GND}
N 3450 510 3510 510 {
lab=#net152}
N 3580 630 3590 630 {
lab=GND}
N 3590 630 3590 760 {
lab=GND}
N 3580 760 3590 760 {
lab=GND}
N 3580 710 3590 710 {
lab=GND}
N 3720 660 3720 680 {
lab=#net153}
N 3720 740 3720 770 {
lab=GND}
N 3720 630 3730 630 {
lab=GND}
N 3730 630 3730 760 {
lab=GND}
N 3720 760 3730 760 {
lab=GND}
N 3720 710 3730 710 {
lab=GND}
N 3580 600 3720 600 {
lab=#net148}
N 3680 630 3680 670 {
lab=VBIAS}
N 3540 670 3680 670 {
lab=VBIAS}
N 3540 640 3540 670 {
lab=VBIAS}
N 3680 710 3680 750 {
lab=VBIAS}
N 3540 750 3680 750 {
lab=VBIAS}
N 3540 710 3540 750 {
lab=VBIAS}
N 3640 540 3640 600 {
lab=#net148}
N 3540 630 3540 640 {
lab=VBIAS}
N 3520 630 3540 630 {
lab=VBIAS}
N 3520 710 3540 710 {
lab=VBIAS}
N 3770 510 3820 510 {
lab=#net154}
N 3370 510 3450 510 {
lab=#net152}
N 3370 530 3370 590 {
lab=#net154}
N 3370 590 3820 590 {
lab=#net154}
N 3820 510 3820 590 {
lab=#net154}
N 4260 540 4440 540 {
lab=#net155}
N 4260 510 4290 510 {
lab=GND}
N 4290 510 4290 560 {
lab=GND}
N 4410 510 4440 510 {
lab=GND}
N 4410 510 4410 560 {
lab=GND}
N 4260 450 4260 480 {
lab=#net156}
N 4440 440 4440 480 {
lab=#net157}
N 4290 660 4290 680 {
lab=#net158}
N 4290 740 4290 770 {
lab=GND}
N 4160 510 4220 510 {
lab=#net159}
N 4290 630 4300 630 {
lab=GND}
N 4300 630 4300 760 {
lab=GND}
N 4290 760 4300 760 {
lab=GND}
N 4290 710 4300 710 {
lab=GND}
N 4430 660 4430 680 {
lab=#net160}
N 4430 740 4430 770 {
lab=GND}
N 4430 630 4440 630 {
lab=GND}
N 4440 630 4440 760 {
lab=GND}
N 4430 760 4440 760 {
lab=GND}
N 4430 710 4440 710 {
lab=GND}
N 4290 600 4430 600 {
lab=#net155}
N 4390 630 4390 670 {
lab=VBIAS}
N 4250 670 4390 670 {
lab=VBIAS}
N 4250 640 4250 670 {
lab=VBIAS}
N 4390 710 4390 750 {
lab=VBIAS}
N 4250 750 4390 750 {
lab=VBIAS}
N 4250 710 4250 750 {
lab=VBIAS}
N 4350 540 4350 600 {
lab=#net155}
N 4250 630 4250 640 {
lab=VBIAS}
N 4230 630 4250 630 {
lab=VBIAS}
N 4230 710 4250 710 {
lab=VBIAS}
N 4480 510 4530 510 {
lab=#net161}
N 4080 510 4160 510 {
lab=#net159}
N 4080 530 4080 590 {
lab=#net161}
N 4080 590 4530 590 {
lab=#net161}
N 4530 510 4530 590 {
lab=#net161}
N 4960 540 5140 540 {
lab=#net162}
N 4960 510 4990 510 {
lab=GND}
N 4990 510 4990 560 {
lab=GND}
N 5110 510 5140 510 {
lab=GND}
N 5110 510 5110 560 {
lab=GND}
N 4960 450 4960 480 {
lab=#net163}
N 5140 440 5140 480 {
lab=#net164}
N 4990 660 4990 680 {
lab=#net165}
N 4990 740 4990 770 {
lab=GND}
N 4860 510 4920 510 {
lab=#net166}
N 4990 630 5000 630 {
lab=GND}
N 5000 630 5000 760 {
lab=GND}
N 4990 760 5000 760 {
lab=GND}
N 4990 710 5000 710 {
lab=GND}
N 5130 660 5130 680 {
lab=#net167}
N 5130 740 5130 770 {
lab=GND}
N 5130 630 5140 630 {
lab=GND}
N 5140 630 5140 760 {
lab=GND}
N 5130 760 5140 760 {
lab=GND}
N 5130 710 5140 710 {
lab=GND}
N 4990 600 5130 600 {
lab=#net162}
N 5090 630 5090 670 {
lab=VBIAS}
N 4950 670 5090 670 {
lab=VBIAS}
N 4950 640 4950 670 {
lab=VBIAS}
N 5090 710 5090 750 {
lab=VBIAS}
N 4950 750 5090 750 {
lab=VBIAS}
N 4950 710 4950 750 {
lab=VBIAS}
N 5050 540 5050 600 {
lab=#net162}
N 4950 630 4950 640 {
lab=VBIAS}
N 4930 630 4950 630 {
lab=VBIAS}
N 4930 710 4950 710 {
lab=VBIAS}
N 5180 510 5230 510 {
lab=#net168}
N 4780 510 4860 510 {
lab=#net166}
N 4780 530 4780 590 {
lab=#net168}
N 4780 590 5230 590 {
lab=#net168}
N 5230 510 5230 590 {
lab=#net168}
N -70 1050 110 1050 {
lab=#net169}
N -70 1020 -40 1020 {
lab=GND}
N -40 1020 -40 1070 {
lab=GND}
N 80 1020 110 1020 {
lab=GND}
N 80 1020 80 1070 {
lab=GND}
N -70 960 -70 990 {
lab=#net170}
N 110 950 110 990 {
lab=#net171}
N -40 1170 -40 1190 {
lab=#net172}
N -40 1250 -40 1280 {
lab=GND}
N -170 1020 -110 1020 {
lab=#net173}
N -40 1140 -30 1140 {
lab=GND}
N -30 1140 -30 1270 {
lab=GND}
N -40 1270 -30 1270 {
lab=GND}
N -40 1220 -30 1220 {
lab=GND}
N 100 1170 100 1190 {
lab=#net174}
N 100 1250 100 1280 {
lab=GND}
N 100 1140 110 1140 {
lab=GND}
N 110 1140 110 1270 {
lab=GND}
N 100 1270 110 1270 {
lab=GND}
N 100 1220 110 1220 {
lab=GND}
N -40 1110 100 1110 {
lab=#net169}
N 60 1140 60 1180 {
lab=VBIAS}
N -80 1180 60 1180 {
lab=VBIAS}
N -80 1150 -80 1180 {
lab=VBIAS}
N 60 1220 60 1260 {
lab=VBIAS}
N -80 1260 60 1260 {
lab=VBIAS}
N -80 1220 -80 1260 {
lab=VBIAS}
N 20 1050 20 1110 {
lab=#net169}
N -80 1140 -80 1150 {
lab=VBIAS}
N -100 1140 -80 1140 {
lab=VBIAS}
N -100 1220 -80 1220 {
lab=VBIAS}
N 150 1020 200 1020 {
lab=#net175}
N -250 1020 -170 1020 {
lab=#net173}
N -250 1040 -250 1100 {
lab=#net175}
N -250 1100 200 1100 {
lab=#net175}
N 200 1020 200 1100 {
lab=#net175}
N 690 1050 870 1050 {
lab=#net176}
N 690 1020 720 1020 {
lab=GND}
N 720 1020 720 1070 {
lab=GND}
N 840 1020 870 1020 {
lab=GND}
N 840 1020 840 1070 {
lab=GND}
N 690 960 690 990 {
lab=#net177}
N 870 950 870 990 {
lab=#net178}
N 720 1170 720 1190 {
lab=#net179}
N 720 1250 720 1280 {
lab=GND}
N 590 1020 650 1020 {
lab=#net180}
N 720 1140 730 1140 {
lab=GND}
N 730 1140 730 1270 {
lab=GND}
N 720 1270 730 1270 {
lab=GND}
N 720 1220 730 1220 {
lab=GND}
N 860 1170 860 1190 {
lab=#net181}
N 860 1250 860 1280 {
lab=GND}
N 860 1140 870 1140 {
lab=GND}
N 870 1140 870 1270 {
lab=GND}
N 860 1270 870 1270 {
lab=GND}
N 860 1220 870 1220 {
lab=GND}
N 720 1110 860 1110 {
lab=#net176}
N 820 1140 820 1180 {
lab=VBIAS}
N 680 1180 820 1180 {
lab=VBIAS}
N 680 1150 680 1180 {
lab=VBIAS}
N 820 1220 820 1260 {
lab=VBIAS}
N 680 1260 820 1260 {
lab=VBIAS}
N 680 1220 680 1260 {
lab=VBIAS}
N 780 1050 780 1110 {
lab=#net176}
N 680 1140 680 1150 {
lab=VBIAS}
N 660 1140 680 1140 {
lab=VBIAS}
N 660 1220 680 1220 {
lab=VBIAS}
N 910 1020 960 1020 {
lab=#net182}
N 510 1020 590 1020 {
lab=#net180}
N 510 1040 510 1100 {
lab=#net182}
N 510 1100 960 1100 {
lab=#net182}
N 960 1020 960 1100 {
lab=#net182}
N 1390 1050 1570 1050 {
lab=#net183}
N 1390 1020 1420 1020 {
lab=GND}
N 1420 1020 1420 1070 {
lab=GND}
N 1540 1020 1570 1020 {
lab=GND}
N 1540 1020 1540 1070 {
lab=GND}
N 1390 960 1390 990 {
lab=#net184}
N 1570 950 1570 990 {
lab=#net185}
N 1420 1170 1420 1190 {
lab=#net186}
N 1420 1250 1420 1280 {
lab=GND}
N 1290 1020 1350 1020 {
lab=#net187}
N 1420 1140 1430 1140 {
lab=GND}
N 1430 1140 1430 1270 {
lab=GND}
N 1420 1270 1430 1270 {
lab=GND}
N 1420 1220 1430 1220 {
lab=GND}
N 1560 1170 1560 1190 {
lab=#net188}
N 1560 1250 1560 1280 {
lab=GND}
N 1560 1140 1570 1140 {
lab=GND}
N 1570 1140 1570 1270 {
lab=GND}
N 1560 1270 1570 1270 {
lab=GND}
N 1560 1220 1570 1220 {
lab=GND}
N 1420 1110 1560 1110 {
lab=#net183}
N 1520 1140 1520 1180 {
lab=VBIAS}
N 1380 1180 1520 1180 {
lab=VBIAS}
N 1380 1150 1380 1180 {
lab=VBIAS}
N 1520 1220 1520 1260 {
lab=VBIAS}
N 1380 1260 1520 1260 {
lab=VBIAS}
N 1380 1220 1380 1260 {
lab=VBIAS}
N 1480 1050 1480 1110 {
lab=#net183}
N 1380 1140 1380 1150 {
lab=VBIAS}
N 1360 1140 1380 1140 {
lab=VBIAS}
N 1360 1220 1380 1220 {
lab=VBIAS}
N 1610 1020 1660 1020 {
lab=#net189}
N 1210 1020 1290 1020 {
lab=#net187}
N 1210 1040 1210 1100 {
lab=#net189}
N 1210 1100 1660 1100 {
lab=#net189}
N 1660 1020 1660 1100 {
lab=#net189}
N 2120 1050 2300 1050 {
lab=#net190}
N 2120 1020 2150 1020 {
lab=GND}
N 2150 1020 2150 1070 {
lab=GND}
N 2270 1020 2300 1020 {
lab=GND}
N 2270 1020 2270 1070 {
lab=GND}
N 2120 960 2120 990 {
lab=#net191}
N 2300 950 2300 990 {
lab=#net192}
N 2150 1170 2150 1190 {
lab=#net193}
N 2150 1250 2150 1280 {
lab=GND}
N 2020 1020 2080 1020 {
lab=#net194}
N 2150 1140 2160 1140 {
lab=GND}
N 2160 1140 2160 1270 {
lab=GND}
N 2150 1270 2160 1270 {
lab=GND}
N 2150 1220 2160 1220 {
lab=GND}
N 2290 1170 2290 1190 {
lab=#net195}
N 2290 1250 2290 1280 {
lab=GND}
N 2290 1140 2300 1140 {
lab=GND}
N 2300 1140 2300 1270 {
lab=GND}
N 2290 1270 2300 1270 {
lab=GND}
N 2290 1220 2300 1220 {
lab=GND}
N 2150 1110 2290 1110 {
lab=#net190}
N 2250 1140 2250 1180 {
lab=VBIAS}
N 2110 1180 2250 1180 {
lab=VBIAS}
N 2110 1150 2110 1180 {
lab=VBIAS}
N 2250 1220 2250 1260 {
lab=VBIAS}
N 2110 1260 2250 1260 {
lab=VBIAS}
N 2110 1220 2110 1260 {
lab=VBIAS}
N 2210 1050 2210 1110 {
lab=#net190}
N 2110 1140 2110 1150 {
lab=VBIAS}
N 2090 1140 2110 1140 {
lab=VBIAS}
N 2090 1220 2110 1220 {
lab=VBIAS}
N 2340 1020 2390 1020 {
lab=#net196}
N 1940 1020 2020 1020 {
lab=#net194}
N 1940 1040 1940 1100 {
lab=#net196}
N 1940 1100 2390 1100 {
lab=#net196}
N 2390 1020 2390 1100 {
lab=#net196}
N 2840 1050 3020 1050 {
lab=#net197}
N 2840 1020 2870 1020 {
lab=GND}
N 2870 1020 2870 1070 {
lab=GND}
N 2990 1020 3020 1020 {
lab=GND}
N 2990 1020 2990 1070 {
lab=GND}
N 2840 960 2840 990 {
lab=#net198}
N 3020 950 3020 990 {
lab=#net199}
N 2870 1170 2870 1190 {
lab=#net200}
N 2870 1250 2870 1280 {
lab=GND}
N 2740 1020 2800 1020 {
lab=#net201}
N 2870 1140 2880 1140 {
lab=GND}
N 2880 1140 2880 1270 {
lab=GND}
N 2870 1270 2880 1270 {
lab=GND}
N 2870 1220 2880 1220 {
lab=GND}
N 3010 1170 3010 1190 {
lab=#net202}
N 3010 1250 3010 1280 {
lab=GND}
N 3010 1140 3020 1140 {
lab=GND}
N 3020 1140 3020 1270 {
lab=GND}
N 3010 1270 3020 1270 {
lab=GND}
N 3010 1220 3020 1220 {
lab=GND}
N 2870 1110 3010 1110 {
lab=#net197}
N 2970 1140 2970 1180 {
lab=VBIAS}
N 2830 1180 2970 1180 {
lab=VBIAS}
N 2830 1150 2830 1180 {
lab=VBIAS}
N 2970 1220 2970 1260 {
lab=VBIAS}
N 2830 1260 2970 1260 {
lab=VBIAS}
N 2830 1220 2830 1260 {
lab=VBIAS}
N 2930 1050 2930 1110 {
lab=#net197}
N 2830 1140 2830 1150 {
lab=VBIAS}
N 2810 1140 2830 1140 {
lab=VBIAS}
N 2810 1220 2830 1220 {
lab=VBIAS}
N 3060 1020 3110 1020 {
lab=#net203}
N 2660 1020 2740 1020 {
lab=#net201}
N 2660 1040 2660 1100 {
lab=#net203}
N 2660 1100 3110 1100 {
lab=#net203}
N 3110 1020 3110 1100 {
lab=#net203}
N 3550 1050 3730 1050 {
lab=#net204}
N 3550 1020 3580 1020 {
lab=GND}
N 3580 1020 3580 1070 {
lab=GND}
N 3700 1020 3730 1020 {
lab=GND}
N 3700 1020 3700 1070 {
lab=GND}
N 3550 960 3550 990 {
lab=#net205}
N 3730 950 3730 990 {
lab=#net206}
N 3580 1170 3580 1190 {
lab=#net207}
N 3580 1250 3580 1280 {
lab=GND}
N 3450 1020 3510 1020 {
lab=#net208}
N 3580 1140 3590 1140 {
lab=GND}
N 3590 1140 3590 1270 {
lab=GND}
N 3580 1270 3590 1270 {
lab=GND}
N 3580 1220 3590 1220 {
lab=GND}
N 3720 1170 3720 1190 {
lab=#net209}
N 3720 1250 3720 1280 {
lab=GND}
N 3720 1140 3730 1140 {
lab=GND}
N 3730 1140 3730 1270 {
lab=GND}
N 3720 1270 3730 1270 {
lab=GND}
N 3720 1220 3730 1220 {
lab=GND}
N 3580 1110 3720 1110 {
lab=#net204}
N 3680 1140 3680 1180 {
lab=VBIAS}
N 3540 1180 3680 1180 {
lab=VBIAS}
N 3540 1150 3540 1180 {
lab=VBIAS}
N 3680 1220 3680 1260 {
lab=VBIAS}
N 3540 1260 3680 1260 {
lab=VBIAS}
N 3540 1220 3540 1260 {
lab=VBIAS}
N 3640 1050 3640 1110 {
lab=#net204}
N 3540 1140 3540 1150 {
lab=VBIAS}
N 3520 1140 3540 1140 {
lab=VBIAS}
N 3520 1220 3540 1220 {
lab=VBIAS}
N 3770 1020 3820 1020 {
lab=#net210}
N 3370 1020 3450 1020 {
lab=#net208}
N 3370 1040 3370 1100 {
lab=#net210}
N 3370 1100 3820 1100 {
lab=#net210}
N 3820 1020 3820 1100 {
lab=#net210}
N 4260 1050 4440 1050 {
lab=#net211}
N 4260 1020 4290 1020 {
lab=GND}
N 4290 1020 4290 1070 {
lab=GND}
N 4410 1020 4440 1020 {
lab=GND}
N 4410 1020 4410 1070 {
lab=GND}
N 4260 960 4260 990 {
lab=#net212}
N 4440 950 4440 990 {
lab=#net213}
N 4290 1170 4290 1190 {
lab=#net214}
N 4290 1250 4290 1280 {
lab=GND}
N 4160 1020 4220 1020 {
lab=#net215}
N 4290 1140 4300 1140 {
lab=GND}
N 4300 1140 4300 1270 {
lab=GND}
N 4290 1270 4300 1270 {
lab=GND}
N 4290 1220 4300 1220 {
lab=GND}
N 4430 1170 4430 1190 {
lab=#net216}
N 4430 1250 4430 1280 {
lab=GND}
N 4430 1140 4440 1140 {
lab=GND}
N 4440 1140 4440 1270 {
lab=GND}
N 4430 1270 4440 1270 {
lab=GND}
N 4430 1220 4440 1220 {
lab=GND}
N 4290 1110 4430 1110 {
lab=#net211}
N 4390 1140 4390 1180 {
lab=VBIAS}
N 4250 1180 4390 1180 {
lab=VBIAS}
N 4250 1150 4250 1180 {
lab=VBIAS}
N 4390 1220 4390 1260 {
lab=VBIAS}
N 4250 1260 4390 1260 {
lab=VBIAS}
N 4250 1220 4250 1260 {
lab=VBIAS}
N 4350 1050 4350 1110 {
lab=#net211}
N 4250 1140 4250 1150 {
lab=VBIAS}
N 4230 1140 4250 1140 {
lab=VBIAS}
N 4230 1220 4250 1220 {
lab=VBIAS}
N 4480 1020 4530 1020 {
lab=#net217}
N 4080 1020 4160 1020 {
lab=#net215}
N 4080 1040 4080 1100 {
lab=#net217}
N 4080 1100 4530 1100 {
lab=#net217}
N 4530 1020 4530 1100 {
lab=#net217}
N 4960 1050 5140 1050 {
lab=#net218}
N 4960 1020 4990 1020 {
lab=GND}
N 4990 1020 4990 1070 {
lab=GND}
N 5110 1020 5140 1020 {
lab=GND}
N 5110 1020 5110 1070 {
lab=GND}
N 4960 960 4960 990 {
lab=#net219}
N 5140 950 5140 990 {
lab=#net220}
N 4990 1170 4990 1190 {
lab=#net221}
N 4990 1250 4990 1280 {
lab=GND}
N 4860 1020 4920 1020 {
lab=#net222}
N 4990 1140 5000 1140 {
lab=GND}
N 5000 1140 5000 1270 {
lab=GND}
N 4990 1270 5000 1270 {
lab=GND}
N 4990 1220 5000 1220 {
lab=GND}
N 5130 1170 5130 1190 {
lab=#net223}
N 5130 1250 5130 1280 {
lab=GND}
N 5130 1140 5140 1140 {
lab=GND}
N 5140 1140 5140 1270 {
lab=GND}
N 5130 1270 5140 1270 {
lab=GND}
N 5130 1220 5140 1220 {
lab=GND}
N 4990 1110 5130 1110 {
lab=#net218}
N 5090 1140 5090 1180 {
lab=VBIAS}
N 4950 1180 5090 1180 {
lab=VBIAS}
N 4950 1150 4950 1180 {
lab=VBIAS}
N 5090 1220 5090 1260 {
lab=VBIAS}
N 4950 1260 5090 1260 {
lab=VBIAS}
N 4950 1220 4950 1260 {
lab=VBIAS}
N 5050 1050 5050 1110 {
lab=#net218}
N 4950 1140 4950 1150 {
lab=VBIAS}
N 4930 1140 4950 1140 {
lab=VBIAS}
N 4930 1220 4950 1220 {
lab=VBIAS}
N 5180 1020 5230 1020 {
lab=#net224}
N 4780 1020 4860 1020 {
lab=#net222}
N 4780 1040 4780 1100 {
lab=#net224}
N 4780 1100 5230 1100 {
lab=#net224}
N 5230 1020 5230 1100 {
lab=#net224}
N -70 1520 110 1520 {
lab=#net225}
N -70 1490 -40 1490 {
lab=GND}
N -40 1490 -40 1540 {
lab=GND}
N 80 1490 110 1490 {
lab=GND}
N 80 1490 80 1540 {
lab=GND}
N -70 1430 -70 1460 {
lab=#net226}
N 110 1420 110 1460 {
lab=#net227}
N -40 1640 -40 1660 {
lab=#net228}
N -40 1720 -40 1750 {
lab=GND}
N -170 1490 -110 1490 {
lab=#net229}
N -40 1610 -30 1610 {
lab=GND}
N -30 1610 -30 1740 {
lab=GND}
N -40 1740 -30 1740 {
lab=GND}
N -40 1690 -30 1690 {
lab=GND}
N 100 1640 100 1660 {
lab=#net230}
N 100 1720 100 1750 {
lab=GND}
N 100 1610 110 1610 {
lab=GND}
N 110 1610 110 1740 {
lab=GND}
N 100 1740 110 1740 {
lab=GND}
N 100 1690 110 1690 {
lab=GND}
N -40 1580 100 1580 {
lab=#net225}
N 60 1610 60 1650 {
lab=VBIAS}
N -80 1650 60 1650 {
lab=VBIAS}
N -80 1620 -80 1650 {
lab=VBIAS}
N 60 1690 60 1730 {
lab=VBIAS}
N -80 1730 60 1730 {
lab=VBIAS}
N -80 1690 -80 1730 {
lab=VBIAS}
N 20 1520 20 1580 {
lab=#net225}
N -80 1610 -80 1620 {
lab=VBIAS}
N -100 1610 -80 1610 {
lab=VBIAS}
N -100 1690 -80 1690 {
lab=VBIAS}
N 150 1490 200 1490 {
lab=#net231}
N -250 1490 -170 1490 {
lab=#net229}
N -250 1510 -250 1570 {
lab=#net231}
N -250 1570 200 1570 {
lab=#net231}
N 200 1490 200 1570 {
lab=#net231}
N 690 1520 870 1520 {
lab=#net232}
N 690 1490 720 1490 {
lab=GND}
N 720 1490 720 1540 {
lab=GND}
N 840 1490 870 1490 {
lab=GND}
N 840 1490 840 1540 {
lab=GND}
N 690 1430 690 1460 {
lab=#net233}
N 870 1420 870 1460 {
lab=#net234}
N 720 1640 720 1660 {
lab=#net235}
N 720 1720 720 1750 {
lab=GND}
N 590 1490 650 1490 {
lab=#net236}
N 720 1610 730 1610 {
lab=GND}
N 730 1610 730 1740 {
lab=GND}
N 720 1740 730 1740 {
lab=GND}
N 720 1690 730 1690 {
lab=GND}
N 860 1640 860 1660 {
lab=#net237}
N 860 1720 860 1750 {
lab=GND}
N 860 1610 870 1610 {
lab=GND}
N 870 1610 870 1740 {
lab=GND}
N 860 1740 870 1740 {
lab=GND}
N 860 1690 870 1690 {
lab=GND}
N 720 1580 860 1580 {
lab=#net232}
N 820 1610 820 1650 {
lab=VBIAS}
N 680 1650 820 1650 {
lab=VBIAS}
N 680 1620 680 1650 {
lab=VBIAS}
N 820 1690 820 1730 {
lab=VBIAS}
N 680 1730 820 1730 {
lab=VBIAS}
N 680 1690 680 1730 {
lab=VBIAS}
N 780 1520 780 1580 {
lab=#net232}
N 680 1610 680 1620 {
lab=VBIAS}
N 660 1610 680 1610 {
lab=VBIAS}
N 660 1690 680 1690 {
lab=VBIAS}
N 910 1490 960 1490 {
lab=#net238}
N 510 1490 590 1490 {
lab=#net236}
N 510 1510 510 1570 {
lab=#net238}
N 510 1570 960 1570 {
lab=#net238}
N 960 1490 960 1570 {
lab=#net238}
N 1390 1520 1570 1520 {
lab=#net239}
N 1390 1490 1420 1490 {
lab=GND}
N 1420 1490 1420 1540 {
lab=GND}
N 1540 1490 1570 1490 {
lab=GND}
N 1540 1490 1540 1540 {
lab=GND}
N 1390 1430 1390 1460 {
lab=#net240}
N 1570 1420 1570 1460 {
lab=#net241}
N 1420 1640 1420 1660 {
lab=#net242}
N 1420 1720 1420 1750 {
lab=GND}
N 1290 1490 1350 1490 {
lab=#net243}
N 1420 1610 1430 1610 {
lab=GND}
N 1430 1610 1430 1740 {
lab=GND}
N 1420 1740 1430 1740 {
lab=GND}
N 1420 1690 1430 1690 {
lab=GND}
N 1560 1640 1560 1660 {
lab=#net244}
N 1560 1720 1560 1750 {
lab=GND}
N 1560 1610 1570 1610 {
lab=GND}
N 1570 1610 1570 1740 {
lab=GND}
N 1560 1740 1570 1740 {
lab=GND}
N 1560 1690 1570 1690 {
lab=GND}
N 1420 1580 1560 1580 {
lab=#net239}
N 1520 1610 1520 1650 {
lab=VBIAS}
N 1380 1650 1520 1650 {
lab=VBIAS}
N 1380 1620 1380 1650 {
lab=VBIAS}
N 1520 1690 1520 1730 {
lab=VBIAS}
N 1380 1730 1520 1730 {
lab=VBIAS}
N 1380 1690 1380 1730 {
lab=VBIAS}
N 1480 1520 1480 1580 {
lab=#net239}
N 1380 1610 1380 1620 {
lab=VBIAS}
N 1360 1610 1380 1610 {
lab=VBIAS}
N 1360 1690 1380 1690 {
lab=VBIAS}
N 1610 1490 1660 1490 {
lab=#net245}
N 1210 1490 1290 1490 {
lab=#net243}
N 1210 1510 1210 1570 {
lab=#net245}
N 1210 1570 1660 1570 {
lab=#net245}
N 1660 1490 1660 1570 {
lab=#net245}
N 2120 1520 2300 1520 {
lab=#net246}
N 2120 1490 2150 1490 {
lab=GND}
N 2150 1490 2150 1540 {
lab=GND}
N 2270 1490 2300 1490 {
lab=GND}
N 2270 1490 2270 1540 {
lab=GND}
N 2120 1430 2120 1460 {
lab=#net247}
N 2300 1420 2300 1460 {
lab=#net248}
N 2150 1640 2150 1660 {
lab=#net249}
N 2150 1720 2150 1750 {
lab=GND}
N 2020 1490 2080 1490 {
lab=#net250}
N 2150 1610 2160 1610 {
lab=GND}
N 2160 1610 2160 1740 {
lab=GND}
N 2150 1740 2160 1740 {
lab=GND}
N 2150 1690 2160 1690 {
lab=GND}
N 2290 1640 2290 1660 {
lab=#net251}
N 2290 1720 2290 1750 {
lab=GND}
N 2290 1610 2300 1610 {
lab=GND}
N 2300 1610 2300 1740 {
lab=GND}
N 2290 1740 2300 1740 {
lab=GND}
N 2290 1690 2300 1690 {
lab=GND}
N 2150 1580 2290 1580 {
lab=#net246}
N 2250 1610 2250 1650 {
lab=VBIAS}
N 2110 1650 2250 1650 {
lab=VBIAS}
N 2110 1620 2110 1650 {
lab=VBIAS}
N 2250 1690 2250 1730 {
lab=VBIAS}
N 2110 1730 2250 1730 {
lab=VBIAS}
N 2110 1690 2110 1730 {
lab=VBIAS}
N 2210 1520 2210 1580 {
lab=#net246}
N 2110 1610 2110 1620 {
lab=VBIAS}
N 2090 1610 2110 1610 {
lab=VBIAS}
N 2090 1690 2110 1690 {
lab=VBIAS}
N 2340 1490 2390 1490 {
lab=#net252}
N 1940 1490 2020 1490 {
lab=#net250}
N 1940 1510 1940 1570 {
lab=#net252}
N 1940 1570 2390 1570 {
lab=#net252}
N 2390 1490 2390 1570 {
lab=#net252}
N 2840 1520 3020 1520 {
lab=#net253}
N 2840 1490 2870 1490 {
lab=GND}
N 2870 1490 2870 1540 {
lab=GND}
N 2990 1490 3020 1490 {
lab=GND}
N 2990 1490 2990 1540 {
lab=GND}
N 2840 1430 2840 1460 {
lab=#net254}
N 3020 1420 3020 1460 {
lab=#net255}
N 2870 1640 2870 1660 {
lab=#net256}
N 2870 1720 2870 1750 {
lab=GND}
N 2740 1490 2800 1490 {
lab=#net257}
N 2870 1610 2880 1610 {
lab=GND}
N 2880 1610 2880 1740 {
lab=GND}
N 2870 1740 2880 1740 {
lab=GND}
N 2870 1690 2880 1690 {
lab=GND}
N 3010 1640 3010 1660 {
lab=#net258}
N 3010 1720 3010 1750 {
lab=GND}
N 3010 1610 3020 1610 {
lab=GND}
N 3020 1610 3020 1740 {
lab=GND}
N 3010 1740 3020 1740 {
lab=GND}
N 3010 1690 3020 1690 {
lab=GND}
N 2870 1580 3010 1580 {
lab=#net253}
N 2970 1610 2970 1650 {
lab=VBIAS}
N 2830 1650 2970 1650 {
lab=VBIAS}
N 2830 1620 2830 1650 {
lab=VBIAS}
N 2970 1690 2970 1730 {
lab=VBIAS}
N 2830 1730 2970 1730 {
lab=VBIAS}
N 2830 1690 2830 1730 {
lab=VBIAS}
N 2930 1520 2930 1580 {
lab=#net253}
N 2830 1610 2830 1620 {
lab=VBIAS}
N 2810 1610 2830 1610 {
lab=VBIAS}
N 2810 1690 2830 1690 {
lab=VBIAS}
N 3060 1490 3110 1490 {
lab=#net259}
N 2660 1490 2740 1490 {
lab=#net257}
N 2660 1510 2660 1570 {
lab=#net259}
N 2660 1570 3110 1570 {
lab=#net259}
N 3110 1490 3110 1570 {
lab=#net259}
N 3550 1520 3730 1520 {
lab=#net260}
N 3550 1490 3580 1490 {
lab=GND}
N 3580 1490 3580 1540 {
lab=GND}
N 3700 1490 3730 1490 {
lab=GND}
N 3700 1490 3700 1540 {
lab=GND}
N 3550 1430 3550 1460 {
lab=#net261}
N 3730 1420 3730 1460 {
lab=#net262}
N 3580 1640 3580 1660 {
lab=#net263}
N 3580 1720 3580 1750 {
lab=GND}
N 3450 1490 3510 1490 {
lab=#net264}
N 3580 1610 3590 1610 {
lab=GND}
N 3590 1610 3590 1740 {
lab=GND}
N 3580 1740 3590 1740 {
lab=GND}
N 3580 1690 3590 1690 {
lab=GND}
N 3720 1640 3720 1660 {
lab=#net265}
N 3720 1720 3720 1750 {
lab=GND}
N 3720 1610 3730 1610 {
lab=GND}
N 3730 1610 3730 1740 {
lab=GND}
N 3720 1740 3730 1740 {
lab=GND}
N 3720 1690 3730 1690 {
lab=GND}
N 3580 1580 3720 1580 {
lab=#net260}
N 3680 1610 3680 1650 {
lab=VBIAS}
N 3540 1650 3680 1650 {
lab=VBIAS}
N 3540 1620 3540 1650 {
lab=VBIAS}
N 3680 1690 3680 1730 {
lab=VBIAS}
N 3540 1730 3680 1730 {
lab=VBIAS}
N 3540 1690 3540 1730 {
lab=VBIAS}
N 3640 1520 3640 1580 {
lab=#net260}
N 3540 1610 3540 1620 {
lab=VBIAS}
N 3520 1610 3540 1610 {
lab=VBIAS}
N 3520 1690 3540 1690 {
lab=VBIAS}
N 3770 1490 3820 1490 {
lab=#net266}
N 3370 1490 3450 1490 {
lab=#net264}
N 3370 1510 3370 1570 {
lab=#net266}
N 3370 1570 3820 1570 {
lab=#net266}
N 3820 1490 3820 1570 {
lab=#net266}
N 4260 1520 4440 1520 {
lab=#net267}
N 4260 1490 4290 1490 {
lab=GND}
N 4290 1490 4290 1540 {
lab=GND}
N 4410 1490 4440 1490 {
lab=GND}
N 4410 1490 4410 1540 {
lab=GND}
N 4260 1430 4260 1460 {
lab=#net268}
N 4440 1420 4440 1460 {
lab=#net269}
N 4290 1640 4290 1660 {
lab=#net270}
N 4290 1720 4290 1750 {
lab=GND}
N 4160 1490 4220 1490 {
lab=#net271}
N 4290 1610 4300 1610 {
lab=GND}
N 4300 1610 4300 1740 {
lab=GND}
N 4290 1740 4300 1740 {
lab=GND}
N 4290 1690 4300 1690 {
lab=GND}
N 4430 1640 4430 1660 {
lab=#net272}
N 4430 1720 4430 1750 {
lab=GND}
N 4430 1610 4440 1610 {
lab=GND}
N 4440 1610 4440 1740 {
lab=GND}
N 4430 1740 4440 1740 {
lab=GND}
N 4430 1690 4440 1690 {
lab=GND}
N 4290 1580 4430 1580 {
lab=#net267}
N 4390 1610 4390 1650 {
lab=VBIAS}
N 4250 1650 4390 1650 {
lab=VBIAS}
N 4250 1620 4250 1650 {
lab=VBIAS}
N 4390 1690 4390 1730 {
lab=VBIAS}
N 4250 1730 4390 1730 {
lab=VBIAS}
N 4250 1690 4250 1730 {
lab=VBIAS}
N 4350 1520 4350 1580 {
lab=#net267}
N 4250 1610 4250 1620 {
lab=VBIAS}
N 4230 1610 4250 1610 {
lab=VBIAS}
N 4230 1690 4250 1690 {
lab=VBIAS}
N 4480 1490 4530 1490 {
lab=#net273}
N 4080 1490 4160 1490 {
lab=#net271}
N 4080 1510 4080 1570 {
lab=#net273}
N 4080 1570 4530 1570 {
lab=#net273}
N 4530 1490 4530 1570 {
lab=#net273}
N 4960 1520 5140 1520 {
lab=#net274}
N 4960 1490 4990 1490 {
lab=GND}
N 4990 1490 4990 1540 {
lab=GND}
N 5110 1490 5140 1490 {
lab=GND}
N 5110 1490 5110 1540 {
lab=GND}
N 4960 1430 4960 1460 {
lab=#net275}
N 5140 1420 5140 1460 {
lab=#net276}
N 4990 1640 4990 1660 {
lab=#net277}
N 4990 1720 4990 1750 {
lab=GND}
N 4860 1490 4920 1490 {
lab=#net278}
N 4990 1610 5000 1610 {
lab=GND}
N 5000 1610 5000 1740 {
lab=GND}
N 4990 1740 5000 1740 {
lab=GND}
N 4990 1690 5000 1690 {
lab=GND}
N 5130 1640 5130 1660 {
lab=#net279}
N 5130 1720 5130 1750 {
lab=GND}
N 5130 1610 5140 1610 {
lab=GND}
N 5140 1610 5140 1740 {
lab=GND}
N 5130 1740 5140 1740 {
lab=GND}
N 5130 1690 5140 1690 {
lab=GND}
N 4990 1580 5130 1580 {
lab=#net274}
N 5090 1610 5090 1650 {
lab=VBIAS}
N 4950 1650 5090 1650 {
lab=VBIAS}
N 4950 1620 4950 1650 {
lab=VBIAS}
N 5090 1690 5090 1730 {
lab=VBIAS}
N 4950 1730 5090 1730 {
lab=VBIAS}
N 4950 1690 4950 1730 {
lab=VBIAS}
N 5050 1520 5050 1580 {
lab=#net274}
N 4950 1610 4950 1620 {
lab=VBIAS}
N 4930 1610 4950 1610 {
lab=VBIAS}
N 4930 1690 4950 1690 {
lab=VBIAS}
N 5180 1490 5230 1490 {
lab=#net280}
N 4780 1490 4860 1490 {
lab=#net278}
N 4780 1510 4780 1570 {
lab=#net280}
N 4780 1570 5230 1570 {
lab=#net280}
N 5230 1490 5230 1570 {
lab=#net280}
N -70 2020 110 2020 {
lab=#net281}
N -70 1990 -40 1990 {
lab=GND}
N -40 1990 -40 2040 {
lab=GND}
N 80 1990 110 1990 {
lab=GND}
N 80 1990 80 2040 {
lab=GND}
N -70 1930 -70 1960 {
lab=#net282}
N 110 1920 110 1960 {
lab=#net283}
N -40 2140 -40 2160 {
lab=#net284}
N -40 2220 -40 2250 {
lab=GND}
N -170 1990 -110 1990 {
lab=#net285}
N -40 2110 -30 2110 {
lab=GND}
N -30 2110 -30 2240 {
lab=GND}
N -40 2240 -30 2240 {
lab=GND}
N -40 2190 -30 2190 {
lab=GND}
N 100 2140 100 2160 {
lab=#net286}
N 100 2220 100 2250 {
lab=GND}
N 100 2110 110 2110 {
lab=GND}
N 110 2110 110 2240 {
lab=GND}
N 100 2240 110 2240 {
lab=GND}
N 100 2190 110 2190 {
lab=GND}
N -40 2080 100 2080 {
lab=#net281}
N 60 2110 60 2150 {
lab=VBIAS}
N -80 2150 60 2150 {
lab=VBIAS}
N -80 2120 -80 2150 {
lab=VBIAS}
N 60 2190 60 2230 {
lab=VBIAS}
N -80 2230 60 2230 {
lab=VBIAS}
N -80 2190 -80 2230 {
lab=VBIAS}
N 20 2020 20 2080 {
lab=#net281}
N -80 2110 -80 2120 {
lab=VBIAS}
N -100 2110 -80 2110 {
lab=VBIAS}
N -100 2190 -80 2190 {
lab=VBIAS}
N 150 1990 200 1990 {
lab=#net287}
N -250 1990 -170 1990 {
lab=#net285}
N -250 2010 -250 2070 {
lab=#net287}
N -250 2070 200 2070 {
lab=#net287}
N 200 1990 200 2070 {
lab=#net287}
N 690 2020 870 2020 {
lab=#net288}
N 690 1990 720 1990 {
lab=GND}
N 720 1990 720 2040 {
lab=GND}
N 840 1990 870 1990 {
lab=GND}
N 840 1990 840 2040 {
lab=GND}
N 690 1930 690 1960 {
lab=#net289}
N 870 1920 870 1960 {
lab=#net290}
N 720 2140 720 2160 {
lab=#net291}
N 720 2220 720 2250 {
lab=GND}
N 590 1990 650 1990 {
lab=#net292}
N 720 2110 730 2110 {
lab=GND}
N 730 2110 730 2240 {
lab=GND}
N 720 2240 730 2240 {
lab=GND}
N 720 2190 730 2190 {
lab=GND}
N 860 2140 860 2160 {
lab=#net293}
N 860 2220 860 2250 {
lab=GND}
N 860 2110 870 2110 {
lab=GND}
N 870 2110 870 2240 {
lab=GND}
N 860 2240 870 2240 {
lab=GND}
N 860 2190 870 2190 {
lab=GND}
N 720 2080 860 2080 {
lab=#net288}
N 820 2110 820 2150 {
lab=VBIAS}
N 680 2150 820 2150 {
lab=VBIAS}
N 680 2120 680 2150 {
lab=VBIAS}
N 820 2190 820 2230 {
lab=VBIAS}
N 680 2230 820 2230 {
lab=VBIAS}
N 680 2190 680 2230 {
lab=VBIAS}
N 780 2020 780 2080 {
lab=#net288}
N 680 2110 680 2120 {
lab=VBIAS}
N 660 2110 680 2110 {
lab=VBIAS}
N 660 2190 680 2190 {
lab=VBIAS}
N 910 1990 960 1990 {
lab=#net294}
N 510 1990 590 1990 {
lab=#net292}
N 510 2010 510 2070 {
lab=#net294}
N 510 2070 960 2070 {
lab=#net294}
N 960 1990 960 2070 {
lab=#net294}
N 1390 2020 1570 2020 {
lab=#net295}
N 1390 1990 1420 1990 {
lab=GND}
N 1420 1990 1420 2040 {
lab=GND}
N 1540 1990 1570 1990 {
lab=GND}
N 1540 1990 1540 2040 {
lab=GND}
N 1390 1930 1390 1960 {
lab=#net296}
N 1570 1920 1570 1960 {
lab=#net297}
N 1420 2140 1420 2160 {
lab=#net298}
N 1420 2220 1420 2250 {
lab=GND}
N 1290 1990 1350 1990 {
lab=#net299}
N 1420 2110 1430 2110 {
lab=GND}
N 1430 2110 1430 2240 {
lab=GND}
N 1420 2240 1430 2240 {
lab=GND}
N 1420 2190 1430 2190 {
lab=GND}
N 1560 2140 1560 2160 {
lab=#net300}
N 1560 2220 1560 2250 {
lab=GND}
N 1560 2110 1570 2110 {
lab=GND}
N 1570 2110 1570 2240 {
lab=GND}
N 1560 2240 1570 2240 {
lab=GND}
N 1560 2190 1570 2190 {
lab=GND}
N 1420 2080 1560 2080 {
lab=#net295}
N 1520 2110 1520 2150 {
lab=VBIAS}
N 1380 2150 1520 2150 {
lab=VBIAS}
N 1380 2120 1380 2150 {
lab=VBIAS}
N 1520 2190 1520 2230 {
lab=VBIAS}
N 1380 2230 1520 2230 {
lab=VBIAS}
N 1380 2190 1380 2230 {
lab=VBIAS}
N 1480 2020 1480 2080 {
lab=#net295}
N 1380 2110 1380 2120 {
lab=VBIAS}
N 1360 2110 1380 2110 {
lab=VBIAS}
N 1360 2190 1380 2190 {
lab=VBIAS}
N 1610 1990 1660 1990 {
lab=#net301}
N 1210 1990 1290 1990 {
lab=#net299}
N 1210 2010 1210 2070 {
lab=#net301}
N 1210 2070 1660 2070 {
lab=#net301}
N 1660 1990 1660 2070 {
lab=#net301}
N 2120 2020 2300 2020 {
lab=#net302}
N 2120 1990 2150 1990 {
lab=GND}
N 2150 1990 2150 2040 {
lab=GND}
N 2270 1990 2300 1990 {
lab=GND}
N 2270 1990 2270 2040 {
lab=GND}
N 2120 1930 2120 1960 {
lab=#net303}
N 2300 1920 2300 1960 {
lab=#net304}
N 2150 2140 2150 2160 {
lab=#net305}
N 2150 2220 2150 2250 {
lab=GND}
N 2020 1990 2080 1990 {
lab=#net306}
N 2150 2110 2160 2110 {
lab=GND}
N 2160 2110 2160 2240 {
lab=GND}
N 2150 2240 2160 2240 {
lab=GND}
N 2150 2190 2160 2190 {
lab=GND}
N 2290 2140 2290 2160 {
lab=#net307}
N 2290 2220 2290 2250 {
lab=GND}
N 2290 2110 2300 2110 {
lab=GND}
N 2300 2110 2300 2240 {
lab=GND}
N 2290 2240 2300 2240 {
lab=GND}
N 2290 2190 2300 2190 {
lab=GND}
N 2150 2080 2290 2080 {
lab=#net302}
N 2250 2110 2250 2150 {
lab=VBIAS}
N 2110 2150 2250 2150 {
lab=VBIAS}
N 2110 2120 2110 2150 {
lab=VBIAS}
N 2250 2190 2250 2230 {
lab=VBIAS}
N 2110 2230 2250 2230 {
lab=VBIAS}
N 2110 2190 2110 2230 {
lab=VBIAS}
N 2210 2020 2210 2080 {
lab=#net302}
N 2110 2110 2110 2120 {
lab=VBIAS}
N 2090 2110 2110 2110 {
lab=VBIAS}
N 2090 2190 2110 2190 {
lab=VBIAS}
N 2340 1990 2390 1990 {
lab=#net308}
N 1940 1990 2020 1990 {
lab=#net306}
N 1940 2010 1940 2070 {
lab=#net308}
N 1940 2070 2390 2070 {
lab=#net308}
N 2390 1990 2390 2070 {
lab=#net308}
N 2840 2020 3020 2020 {
lab=#net309}
N 2840 1990 2870 1990 {
lab=GND}
N 2870 1990 2870 2040 {
lab=GND}
N 2990 1990 3020 1990 {
lab=GND}
N 2990 1990 2990 2040 {
lab=GND}
N 2840 1930 2840 1960 {
lab=#net310}
N 3020 1920 3020 1960 {
lab=#net311}
N 2870 2140 2870 2160 {
lab=#net312}
N 2870 2220 2870 2250 {
lab=GND}
N 2740 1990 2800 1990 {
lab=#net313}
N 2870 2110 2880 2110 {
lab=GND}
N 2880 2110 2880 2240 {
lab=GND}
N 2870 2240 2880 2240 {
lab=GND}
N 2870 2190 2880 2190 {
lab=GND}
N 3010 2140 3010 2160 {
lab=#net314}
N 3010 2220 3010 2250 {
lab=GND}
N 3010 2110 3020 2110 {
lab=GND}
N 3020 2110 3020 2240 {
lab=GND}
N 3010 2240 3020 2240 {
lab=GND}
N 3010 2190 3020 2190 {
lab=GND}
N 2870 2080 3010 2080 {
lab=#net309}
N 2970 2110 2970 2150 {
lab=VBIAS}
N 2830 2150 2970 2150 {
lab=VBIAS}
N 2830 2120 2830 2150 {
lab=VBIAS}
N 2970 2190 2970 2230 {
lab=VBIAS}
N 2830 2230 2970 2230 {
lab=VBIAS}
N 2830 2190 2830 2230 {
lab=VBIAS}
N 2930 2020 2930 2080 {
lab=#net309}
N 2830 2110 2830 2120 {
lab=VBIAS}
N 2810 2110 2830 2110 {
lab=VBIAS}
N 2810 2190 2830 2190 {
lab=VBIAS}
N 3060 1990 3110 1990 {
lab=#net315}
N 2660 1990 2740 1990 {
lab=#net313}
N 2660 2010 2660 2070 {
lab=#net315}
N 2660 2070 3110 2070 {
lab=#net315}
N 3110 1990 3110 2070 {
lab=#net315}
N 3550 2020 3730 2020 {
lab=#net316}
N 3550 1990 3580 1990 {
lab=GND}
N 3580 1990 3580 2040 {
lab=GND}
N 3700 1990 3730 1990 {
lab=GND}
N 3700 1990 3700 2040 {
lab=GND}
N 3550 1930 3550 1960 {
lab=#net317}
N 3730 1920 3730 1960 {
lab=#net318}
N 3580 2140 3580 2160 {
lab=#net319}
N 3580 2220 3580 2250 {
lab=GND}
N 3450 1990 3510 1990 {
lab=#net320}
N 3580 2110 3590 2110 {
lab=GND}
N 3590 2110 3590 2240 {
lab=GND}
N 3580 2240 3590 2240 {
lab=GND}
N 3580 2190 3590 2190 {
lab=GND}
N 3720 2140 3720 2160 {
lab=#net321}
N 3720 2220 3720 2250 {
lab=GND}
N 3720 2110 3730 2110 {
lab=GND}
N 3730 2110 3730 2240 {
lab=GND}
N 3720 2240 3730 2240 {
lab=GND}
N 3720 2190 3730 2190 {
lab=GND}
N 3580 2080 3720 2080 {
lab=#net316}
N 3680 2110 3680 2150 {
lab=VBIAS}
N 3540 2150 3680 2150 {
lab=VBIAS}
N 3540 2120 3540 2150 {
lab=VBIAS}
N 3680 2190 3680 2230 {
lab=VBIAS}
N 3540 2230 3680 2230 {
lab=VBIAS}
N 3540 2190 3540 2230 {
lab=VBIAS}
N 3640 2020 3640 2080 {
lab=#net316}
N 3540 2110 3540 2120 {
lab=VBIAS}
N 3520 2110 3540 2110 {
lab=VBIAS}
N 3520 2190 3540 2190 {
lab=VBIAS}
N 3770 1990 3820 1990 {
lab=#net322}
N 3370 1990 3450 1990 {
lab=#net320}
N 3370 2010 3370 2070 {
lab=#net322}
N 3370 2070 3820 2070 {
lab=#net322}
N 3820 1990 3820 2070 {
lab=#net322}
N 4260 2020 4440 2020 {
lab=#net323}
N 4260 1990 4290 1990 {
lab=GND}
N 4290 1990 4290 2040 {
lab=GND}
N 4410 1990 4440 1990 {
lab=GND}
N 4410 1990 4410 2040 {
lab=GND}
N 4260 1930 4260 1960 {
lab=#net324}
N 4440 1920 4440 1960 {
lab=#net325}
N 4290 2140 4290 2160 {
lab=#net326}
N 4290 2220 4290 2250 {
lab=GND}
N 4160 1990 4220 1990 {
lab=#net327}
N 4290 2110 4300 2110 {
lab=GND}
N 4300 2110 4300 2240 {
lab=GND}
N 4290 2240 4300 2240 {
lab=GND}
N 4290 2190 4300 2190 {
lab=GND}
N 4430 2140 4430 2160 {
lab=#net328}
N 4430 2220 4430 2250 {
lab=GND}
N 4430 2110 4440 2110 {
lab=GND}
N 4440 2110 4440 2240 {
lab=GND}
N 4430 2240 4440 2240 {
lab=GND}
N 4430 2190 4440 2190 {
lab=GND}
N 4290 2080 4430 2080 {
lab=#net323}
N 4390 2110 4390 2150 {
lab=VBIAS}
N 4250 2150 4390 2150 {
lab=VBIAS}
N 4250 2120 4250 2150 {
lab=VBIAS}
N 4390 2190 4390 2230 {
lab=VBIAS}
N 4250 2230 4390 2230 {
lab=VBIAS}
N 4250 2190 4250 2230 {
lab=VBIAS}
N 4350 2020 4350 2080 {
lab=#net323}
N 4250 2110 4250 2120 {
lab=VBIAS}
N 4230 2110 4250 2110 {
lab=VBIAS}
N 4230 2190 4250 2190 {
lab=VBIAS}
N 4480 1990 4530 1990 {
lab=#net329}
N 4080 1990 4160 1990 {
lab=#net327}
N 4080 2010 4080 2070 {
lab=#net329}
N 4080 2070 4530 2070 {
lab=#net329}
N 4530 1990 4530 2070 {
lab=#net329}
N 4960 2020 5140 2020 {
lab=#net330}
N 4960 1990 4990 1990 {
lab=GND}
N 4990 1990 4990 2040 {
lab=GND}
N 5110 1990 5140 1990 {
lab=GND}
N 5110 1990 5110 2040 {
lab=GND}
N 4960 1930 4960 1960 {
lab=#net331}
N 5140 1920 5140 1960 {
lab=#net332}
N 4990 2140 4990 2160 {
lab=#net333}
N 4990 2220 4990 2250 {
lab=GND}
N 4860 1990 4920 1990 {
lab=#net334}
N 4990 2110 5000 2110 {
lab=GND}
N 5000 2110 5000 2240 {
lab=GND}
N 4990 2240 5000 2240 {
lab=GND}
N 4990 2190 5000 2190 {
lab=GND}
N 5130 2140 5130 2160 {
lab=#net335}
N 5130 2220 5130 2250 {
lab=GND}
N 5130 2110 5140 2110 {
lab=GND}
N 5140 2110 5140 2240 {
lab=GND}
N 5130 2240 5140 2240 {
lab=GND}
N 5130 2190 5140 2190 {
lab=GND}
N 4990 2080 5130 2080 {
lab=#net330}
N 5090 2110 5090 2150 {
lab=VBIAS}
N 4950 2150 5090 2150 {
lab=VBIAS}
N 4950 2120 4950 2150 {
lab=VBIAS}
N 5090 2190 5090 2230 {
lab=VBIAS}
N 4950 2230 5090 2230 {
lab=VBIAS}
N 4950 2190 4950 2230 {
lab=VBIAS}
N 5050 2020 5050 2080 {
lab=#net330}
N 4950 2110 4950 2120 {
lab=VBIAS}
N 4930 2110 4950 2110 {
lab=VBIAS}
N 4930 2190 4950 2190 {
lab=VBIAS}
N 5180 1990 5230 1990 {
lab=#net336}
N 4780 1990 4860 1990 {
lab=#net334}
N 4780 2010 4780 2070 {
lab=#net336}
N 4780 2070 5230 2070 {
lab=#net336}
N 5230 1990 5230 2070 {
lab=#net336}
N -70 2480 110 2480 {
lab=#net337}
N -70 2450 -40 2450 {
lab=GND}
N -40 2450 -40 2500 {
lab=GND}
N 80 2450 110 2450 {
lab=GND}
N 80 2450 80 2500 {
lab=GND}
N -70 2390 -70 2420 {
lab=#net338}
N 110 2380 110 2420 {
lab=#net339}
N -40 2600 -40 2620 {
lab=#net340}
N -40 2680 -40 2710 {
lab=GND}
N -170 2450 -110 2450 {
lab=#net341}
N -40 2570 -30 2570 {
lab=GND}
N -30 2570 -30 2700 {
lab=GND}
N -40 2700 -30 2700 {
lab=GND}
N -40 2650 -30 2650 {
lab=GND}
N 100 2600 100 2620 {
lab=#net342}
N 100 2680 100 2710 {
lab=GND}
N 100 2570 110 2570 {
lab=GND}
N 110 2570 110 2700 {
lab=GND}
N 100 2700 110 2700 {
lab=GND}
N 100 2650 110 2650 {
lab=GND}
N -40 2540 100 2540 {
lab=#net337}
N 60 2570 60 2610 {
lab=VBIAS}
N -80 2610 60 2610 {
lab=VBIAS}
N -80 2580 -80 2610 {
lab=VBIAS}
N 60 2650 60 2690 {
lab=VBIAS}
N -80 2690 60 2690 {
lab=VBIAS}
N -80 2650 -80 2690 {
lab=VBIAS}
N 20 2480 20 2540 {
lab=#net337}
N -80 2570 -80 2580 {
lab=VBIAS}
N -100 2570 -80 2570 {
lab=VBIAS}
N -100 2650 -80 2650 {
lab=VBIAS}
N 150 2450 200 2450 {
lab=#net343}
N -250 2450 -170 2450 {
lab=#net341}
N -250 2470 -250 2530 {
lab=#net343}
N -250 2530 200 2530 {
lab=#net343}
N 200 2450 200 2530 {
lab=#net343}
N 690 2480 870 2480 {
lab=#net344}
N 690 2450 720 2450 {
lab=GND}
N 720 2450 720 2500 {
lab=GND}
N 840 2450 870 2450 {
lab=GND}
N 840 2450 840 2500 {
lab=GND}
N 690 2390 690 2420 {
lab=#net345}
N 870 2380 870 2420 {
lab=#net346}
N 720 2600 720 2620 {
lab=#net347}
N 720 2680 720 2710 {
lab=GND}
N 590 2450 650 2450 {
lab=#net348}
N 720 2570 730 2570 {
lab=GND}
N 730 2570 730 2700 {
lab=GND}
N 720 2700 730 2700 {
lab=GND}
N 720 2650 730 2650 {
lab=GND}
N 860 2600 860 2620 {
lab=#net349}
N 860 2680 860 2710 {
lab=GND}
N 860 2570 870 2570 {
lab=GND}
N 870 2570 870 2700 {
lab=GND}
N 860 2700 870 2700 {
lab=GND}
N 860 2650 870 2650 {
lab=GND}
N 720 2540 860 2540 {
lab=#net344}
N 820 2570 820 2610 {
lab=VBIAS}
N 680 2610 820 2610 {
lab=VBIAS}
N 680 2580 680 2610 {
lab=VBIAS}
N 820 2650 820 2690 {
lab=VBIAS}
N 680 2690 820 2690 {
lab=VBIAS}
N 680 2650 680 2690 {
lab=VBIAS}
N 780 2480 780 2540 {
lab=#net344}
N 680 2570 680 2580 {
lab=VBIAS}
N 660 2570 680 2570 {
lab=VBIAS}
N 660 2650 680 2650 {
lab=VBIAS}
N 910 2450 960 2450 {
lab=#net350}
N 510 2450 590 2450 {
lab=#net348}
N 510 2470 510 2530 {
lab=#net350}
N 510 2530 960 2530 {
lab=#net350}
N 960 2450 960 2530 {
lab=#net350}
N 1390 2480 1570 2480 {
lab=#net351}
N 1390 2450 1420 2450 {
lab=GND}
N 1420 2450 1420 2500 {
lab=GND}
N 1540 2450 1570 2450 {
lab=GND}
N 1540 2450 1540 2500 {
lab=GND}
N 1390 2390 1390 2420 {
lab=#net352}
N 1570 2380 1570 2420 {
lab=#net353}
N 1420 2600 1420 2620 {
lab=#net354}
N 1420 2680 1420 2710 {
lab=GND}
N 1290 2450 1350 2450 {
lab=#net355}
N 1420 2570 1430 2570 {
lab=GND}
N 1430 2570 1430 2700 {
lab=GND}
N 1420 2700 1430 2700 {
lab=GND}
N 1420 2650 1430 2650 {
lab=GND}
N 1560 2600 1560 2620 {
lab=#net356}
N 1560 2680 1560 2710 {
lab=GND}
N 1560 2570 1570 2570 {
lab=GND}
N 1570 2570 1570 2700 {
lab=GND}
N 1560 2700 1570 2700 {
lab=GND}
N 1560 2650 1570 2650 {
lab=GND}
N 1420 2540 1560 2540 {
lab=#net351}
N 1520 2570 1520 2610 {
lab=VBIAS}
N 1380 2610 1520 2610 {
lab=VBIAS}
N 1380 2580 1380 2610 {
lab=VBIAS}
N 1520 2650 1520 2690 {
lab=VBIAS}
N 1380 2690 1520 2690 {
lab=VBIAS}
N 1380 2650 1380 2690 {
lab=VBIAS}
N 1480 2480 1480 2540 {
lab=#net351}
N 1380 2570 1380 2580 {
lab=VBIAS}
N 1360 2570 1380 2570 {
lab=VBIAS}
N 1360 2650 1380 2650 {
lab=VBIAS}
N 1610 2450 1660 2450 {
lab=#net357}
N 1210 2450 1290 2450 {
lab=#net355}
N 1210 2470 1210 2530 {
lab=#net357}
N 1210 2530 1660 2530 {
lab=#net357}
N 1660 2450 1660 2530 {
lab=#net357}
N 2120 2480 2300 2480 {
lab=#net358}
N 2120 2450 2150 2450 {
lab=GND}
N 2150 2450 2150 2500 {
lab=GND}
N 2270 2450 2300 2450 {
lab=GND}
N 2270 2450 2270 2500 {
lab=GND}
N 2120 2390 2120 2420 {
lab=#net359}
N 2300 2380 2300 2420 {
lab=#net360}
N 2150 2600 2150 2620 {
lab=#net361}
N 2150 2680 2150 2710 {
lab=GND}
N 2020 2450 2080 2450 {
lab=#net362}
N 2150 2570 2160 2570 {
lab=GND}
N 2160 2570 2160 2700 {
lab=GND}
N 2150 2700 2160 2700 {
lab=GND}
N 2150 2650 2160 2650 {
lab=GND}
N 2290 2600 2290 2620 {
lab=#net363}
N 2290 2680 2290 2710 {
lab=GND}
N 2290 2570 2300 2570 {
lab=GND}
N 2300 2570 2300 2700 {
lab=GND}
N 2290 2700 2300 2700 {
lab=GND}
N 2290 2650 2300 2650 {
lab=GND}
N 2150 2540 2290 2540 {
lab=#net358}
N 2250 2570 2250 2610 {
lab=VBIAS}
N 2110 2610 2250 2610 {
lab=VBIAS}
N 2110 2580 2110 2610 {
lab=VBIAS}
N 2250 2650 2250 2690 {
lab=VBIAS}
N 2110 2690 2250 2690 {
lab=VBIAS}
N 2110 2650 2110 2690 {
lab=VBIAS}
N 2210 2480 2210 2540 {
lab=#net358}
N 2110 2570 2110 2580 {
lab=VBIAS}
N 2090 2570 2110 2570 {
lab=VBIAS}
N 2090 2650 2110 2650 {
lab=VBIAS}
N 2340 2450 2390 2450 {
lab=#net364}
N 1940 2450 2020 2450 {
lab=#net362}
N 1940 2470 1940 2530 {
lab=#net364}
N 1940 2530 2390 2530 {
lab=#net364}
N 2390 2450 2390 2530 {
lab=#net364}
N 2840 2480 3020 2480 {
lab=#net365}
N 2840 2450 2870 2450 {
lab=GND}
N 2870 2450 2870 2500 {
lab=GND}
N 2990 2450 3020 2450 {
lab=GND}
N 2990 2450 2990 2500 {
lab=GND}
N 2840 2390 2840 2420 {
lab=#net366}
N 3020 2380 3020 2420 {
lab=#net367}
N 2870 2600 2870 2620 {
lab=#net368}
N 2870 2680 2870 2710 {
lab=GND}
N 2740 2450 2800 2450 {
lab=#net369}
N 2870 2570 2880 2570 {
lab=GND}
N 2880 2570 2880 2700 {
lab=GND}
N 2870 2700 2880 2700 {
lab=GND}
N 2870 2650 2880 2650 {
lab=GND}
N 3010 2600 3010 2620 {
lab=#net370}
N 3010 2680 3010 2710 {
lab=GND}
N 3010 2570 3020 2570 {
lab=GND}
N 3020 2570 3020 2700 {
lab=GND}
N 3010 2700 3020 2700 {
lab=GND}
N 3010 2650 3020 2650 {
lab=GND}
N 2870 2540 3010 2540 {
lab=#net365}
N 2970 2570 2970 2610 {
lab=VBIAS}
N 2830 2610 2970 2610 {
lab=VBIAS}
N 2830 2580 2830 2610 {
lab=VBIAS}
N 2970 2650 2970 2690 {
lab=VBIAS}
N 2830 2690 2970 2690 {
lab=VBIAS}
N 2830 2650 2830 2690 {
lab=VBIAS}
N 2930 2480 2930 2540 {
lab=#net365}
N 2830 2570 2830 2580 {
lab=VBIAS}
N 2810 2570 2830 2570 {
lab=VBIAS}
N 2810 2650 2830 2650 {
lab=VBIAS}
N 3060 2450 3110 2450 {
lab=#net371}
N 2660 2450 2740 2450 {
lab=#net369}
N 2660 2470 2660 2530 {
lab=#net371}
N 2660 2530 3110 2530 {
lab=#net371}
N 3110 2450 3110 2530 {
lab=#net371}
N 3550 2480 3730 2480 {
lab=#net372}
N 3550 2450 3580 2450 {
lab=GND}
N 3580 2450 3580 2500 {
lab=GND}
N 3700 2450 3730 2450 {
lab=GND}
N 3700 2450 3700 2500 {
lab=GND}
N 3550 2390 3550 2420 {
lab=#net373}
N 3730 2380 3730 2420 {
lab=#net374}
N 3580 2600 3580 2620 {
lab=#net375}
N 3580 2680 3580 2710 {
lab=GND}
N 3450 2450 3510 2450 {
lab=#net376}
N 3580 2570 3590 2570 {
lab=GND}
N 3590 2570 3590 2700 {
lab=GND}
N 3580 2700 3590 2700 {
lab=GND}
N 3580 2650 3590 2650 {
lab=GND}
N 3720 2600 3720 2620 {
lab=#net377}
N 3720 2680 3720 2710 {
lab=GND}
N 3720 2570 3730 2570 {
lab=GND}
N 3730 2570 3730 2700 {
lab=GND}
N 3720 2700 3730 2700 {
lab=GND}
N 3720 2650 3730 2650 {
lab=GND}
N 3580 2540 3720 2540 {
lab=#net372}
N 3680 2570 3680 2610 {
lab=VBIAS}
N 3540 2610 3680 2610 {
lab=VBIAS}
N 3540 2580 3540 2610 {
lab=VBIAS}
N 3680 2650 3680 2690 {
lab=VBIAS}
N 3540 2690 3680 2690 {
lab=VBIAS}
N 3540 2650 3540 2690 {
lab=VBIAS}
N 3640 2480 3640 2540 {
lab=#net372}
N 3540 2570 3540 2580 {
lab=VBIAS}
N 3520 2570 3540 2570 {
lab=VBIAS}
N 3520 2650 3540 2650 {
lab=VBIAS}
N 3770 2450 3820 2450 {
lab=#net378}
N 3370 2450 3450 2450 {
lab=#net376}
N 3370 2470 3370 2530 {
lab=#net378}
N 3370 2530 3820 2530 {
lab=#net378}
N 3820 2450 3820 2530 {
lab=#net378}
N 4260 2480 4440 2480 {
lab=#net379}
N 4260 2450 4290 2450 {
lab=GND}
N 4290 2450 4290 2500 {
lab=GND}
N 4410 2450 4440 2450 {
lab=GND}
N 4410 2450 4410 2500 {
lab=GND}
N 4260 2390 4260 2420 {
lab=#net380}
N 4440 2380 4440 2420 {
lab=#net381}
N 4290 2600 4290 2620 {
lab=#net382}
N 4290 2680 4290 2710 {
lab=GND}
N 4160 2450 4220 2450 {
lab=#net383}
N 4290 2570 4300 2570 {
lab=GND}
N 4300 2570 4300 2700 {
lab=GND}
N 4290 2700 4300 2700 {
lab=GND}
N 4290 2650 4300 2650 {
lab=GND}
N 4430 2600 4430 2620 {
lab=#net384}
N 4430 2680 4430 2710 {
lab=GND}
N 4430 2570 4440 2570 {
lab=GND}
N 4440 2570 4440 2700 {
lab=GND}
N 4430 2700 4440 2700 {
lab=GND}
N 4430 2650 4440 2650 {
lab=GND}
N 4290 2540 4430 2540 {
lab=#net379}
N 4390 2570 4390 2610 {
lab=VBIAS}
N 4250 2610 4390 2610 {
lab=VBIAS}
N 4250 2580 4250 2610 {
lab=VBIAS}
N 4390 2650 4390 2690 {
lab=VBIAS}
N 4250 2690 4390 2690 {
lab=VBIAS}
N 4250 2650 4250 2690 {
lab=VBIAS}
N 4350 2480 4350 2540 {
lab=#net379}
N 4250 2570 4250 2580 {
lab=VBIAS}
N 4230 2570 4250 2570 {
lab=VBIAS}
N 4230 2650 4250 2650 {
lab=VBIAS}
N 4480 2450 4530 2450 {
lab=#net385}
N 4080 2450 4160 2450 {
lab=#net383}
N 4080 2470 4080 2530 {
lab=#net385}
N 4080 2530 4530 2530 {
lab=#net385}
N 4530 2450 4530 2530 {
lab=#net385}
N 4960 2480 5140 2480 {
lab=#net386}
N 4960 2450 4990 2450 {
lab=GND}
N 4990 2450 4990 2500 {
lab=GND}
N 5110 2450 5140 2450 {
lab=GND}
N 5110 2450 5110 2500 {
lab=GND}
N 4960 2390 4960 2420 {
lab=#net387}
N 5140 2380 5140 2420 {
lab=#net388}
N 4990 2600 4990 2620 {
lab=#net389}
N 4990 2680 4990 2710 {
lab=GND}
N 4860 2450 4920 2450 {
lab=#net390}
N 4990 2570 5000 2570 {
lab=GND}
N 5000 2570 5000 2700 {
lab=GND}
N 4990 2700 5000 2700 {
lab=GND}
N 4990 2650 5000 2650 {
lab=GND}
N 5130 2600 5130 2620 {
lab=#net391}
N 5130 2680 5130 2710 {
lab=GND}
N 5130 2570 5140 2570 {
lab=GND}
N 5140 2570 5140 2700 {
lab=GND}
N 5130 2700 5140 2700 {
lab=GND}
N 5130 2650 5140 2650 {
lab=GND}
N 4990 2540 5130 2540 {
lab=#net386}
N 5090 2570 5090 2610 {
lab=VBIAS}
N 4950 2610 5090 2610 {
lab=VBIAS}
N 4950 2580 4950 2610 {
lab=VBIAS}
N 5090 2650 5090 2690 {
lab=VBIAS}
N 4950 2690 5090 2690 {
lab=VBIAS}
N 4950 2650 4950 2690 {
lab=VBIAS}
N 5050 2480 5050 2540 {
lab=#net386}
N 4950 2570 4950 2580 {
lab=VBIAS}
N 4930 2570 4950 2570 {
lab=VBIAS}
N 4930 2650 4950 2650 {
lab=VBIAS}
N 5180 2450 5230 2450 {
lab=#net392}
N 4780 2450 4860 2450 {
lab=#net390}
N 4780 2470 4780 2530 {
lab=#net392}
N 4780 2530 5230 2530 {
lab=#net392}
N 5230 2450 5230 2530 {
lab=#net392}
N -70 2940 110 2940 {
lab=#net393}
N -70 2910 -40 2910 {
lab=GND}
N -40 2910 -40 2960 {
lab=GND}
N 80 2910 110 2910 {
lab=GND}
N 80 2910 80 2960 {
lab=GND}
N -70 2850 -70 2880 {
lab=#net394}
N 110 2840 110 2880 {
lab=#net395}
N -40 3060 -40 3080 {
lab=#net396}
N -40 3140 -40 3170 {
lab=GND}
N -170 2910 -110 2910 {
lab=#net397}
N -40 3030 -30 3030 {
lab=GND}
N -30 3030 -30 3160 {
lab=GND}
N -40 3160 -30 3160 {
lab=GND}
N -40 3110 -30 3110 {
lab=GND}
N 100 3060 100 3080 {
lab=#net398}
N 100 3140 100 3170 {
lab=GND}
N 100 3030 110 3030 {
lab=GND}
N 110 3030 110 3160 {
lab=GND}
N 100 3160 110 3160 {
lab=GND}
N 100 3110 110 3110 {
lab=GND}
N -40 3000 100 3000 {
lab=#net393}
N 60 3030 60 3070 {
lab=VBIAS}
N -80 3070 60 3070 {
lab=VBIAS}
N -80 3040 -80 3070 {
lab=VBIAS}
N 60 3110 60 3150 {
lab=VBIAS}
N -80 3150 60 3150 {
lab=VBIAS}
N -80 3110 -80 3150 {
lab=VBIAS}
N 20 2940 20 3000 {
lab=#net393}
N -80 3030 -80 3040 {
lab=VBIAS}
N -100 3030 -80 3030 {
lab=VBIAS}
N -100 3110 -80 3110 {
lab=VBIAS}
N 150 2910 200 2910 {
lab=#net399}
N -250 2910 -170 2910 {
lab=#net397}
N -250 2930 -250 2990 {
lab=#net399}
N -250 2990 200 2990 {
lab=#net399}
N 200 2910 200 2990 {
lab=#net399}
N 690 2940 870 2940 {
lab=#net400}
N 690 2910 720 2910 {
lab=GND}
N 720 2910 720 2960 {
lab=GND}
N 840 2910 870 2910 {
lab=GND}
N 840 2910 840 2960 {
lab=GND}
N 690 2850 690 2880 {
lab=#net401}
N 870 2840 870 2880 {
lab=#net402}
N 720 3060 720 3080 {
lab=#net403}
N 720 3140 720 3170 {
lab=GND}
N 590 2910 650 2910 {
lab=#net404}
N 720 3030 730 3030 {
lab=GND}
N 730 3030 730 3160 {
lab=GND}
N 720 3160 730 3160 {
lab=GND}
N 720 3110 730 3110 {
lab=GND}
N 860 3060 860 3080 {
lab=#net405}
N 860 3140 860 3170 {
lab=GND}
N 860 3030 870 3030 {
lab=GND}
N 870 3030 870 3160 {
lab=GND}
N 860 3160 870 3160 {
lab=GND}
N 860 3110 870 3110 {
lab=GND}
N 720 3000 860 3000 {
lab=#net400}
N 820 3030 820 3070 {
lab=VBIAS}
N 680 3070 820 3070 {
lab=VBIAS}
N 680 3040 680 3070 {
lab=VBIAS}
N 820 3110 820 3150 {
lab=VBIAS}
N 680 3150 820 3150 {
lab=VBIAS}
N 680 3110 680 3150 {
lab=VBIAS}
N 780 2940 780 3000 {
lab=#net400}
N 680 3030 680 3040 {
lab=VBIAS}
N 660 3030 680 3030 {
lab=VBIAS}
N 660 3110 680 3110 {
lab=VBIAS}
N 910 2910 960 2910 {
lab=#net406}
N 510 2910 590 2910 {
lab=#net404}
N 510 2930 510 2990 {
lab=#net406}
N 510 2990 960 2990 {
lab=#net406}
N 960 2910 960 2990 {
lab=#net406}
N 1390 2940 1570 2940 {
lab=#net407}
N 1390 2910 1420 2910 {
lab=GND}
N 1420 2910 1420 2960 {
lab=GND}
N 1540 2910 1570 2910 {
lab=GND}
N 1540 2910 1540 2960 {
lab=GND}
N 1390 2850 1390 2880 {
lab=#net408}
N 1570 2840 1570 2880 {
lab=#net409}
N 1420 3060 1420 3080 {
lab=#net410}
N 1420 3140 1420 3170 {
lab=GND}
N 1290 2910 1350 2910 {
lab=#net411}
N 1420 3030 1430 3030 {
lab=GND}
N 1430 3030 1430 3160 {
lab=GND}
N 1420 3160 1430 3160 {
lab=GND}
N 1420 3110 1430 3110 {
lab=GND}
N 1560 3060 1560 3080 {
lab=#net412}
N 1560 3140 1560 3170 {
lab=GND}
N 1560 3030 1570 3030 {
lab=GND}
N 1570 3030 1570 3160 {
lab=GND}
N 1560 3160 1570 3160 {
lab=GND}
N 1560 3110 1570 3110 {
lab=GND}
N 1420 3000 1560 3000 {
lab=#net407}
N 1520 3030 1520 3070 {
lab=VBIAS}
N 1380 3070 1520 3070 {
lab=VBIAS}
N 1380 3040 1380 3070 {
lab=VBIAS}
N 1520 3110 1520 3150 {
lab=VBIAS}
N 1380 3150 1520 3150 {
lab=VBIAS}
N 1380 3110 1380 3150 {
lab=VBIAS}
N 1480 2940 1480 3000 {
lab=#net407}
N 1380 3030 1380 3040 {
lab=VBIAS}
N 1360 3030 1380 3030 {
lab=VBIAS}
N 1360 3110 1380 3110 {
lab=VBIAS}
N 1610 2910 1660 2910 {
lab=#net413}
N 1210 2910 1290 2910 {
lab=#net411}
N 1210 2930 1210 2990 {
lab=#net413}
N 1210 2990 1660 2990 {
lab=#net413}
N 1660 2910 1660 2990 {
lab=#net413}
N 2120 2940 2300 2940 {
lab=#net414}
N 2120 2910 2150 2910 {
lab=GND}
N 2150 2910 2150 2960 {
lab=GND}
N 2270 2910 2300 2910 {
lab=GND}
N 2270 2910 2270 2960 {
lab=GND}
N 2120 2850 2120 2880 {
lab=#net415}
N 2300 2840 2300 2880 {
lab=#net416}
N 2150 3060 2150 3080 {
lab=#net417}
N 2150 3140 2150 3170 {
lab=GND}
N 2020 2910 2080 2910 {
lab=#net418}
N 2150 3030 2160 3030 {
lab=GND}
N 2160 3030 2160 3160 {
lab=GND}
N 2150 3160 2160 3160 {
lab=GND}
N 2150 3110 2160 3110 {
lab=GND}
N 2290 3060 2290 3080 {
lab=#net419}
N 2290 3140 2290 3170 {
lab=GND}
N 2290 3030 2300 3030 {
lab=GND}
N 2300 3030 2300 3160 {
lab=GND}
N 2290 3160 2300 3160 {
lab=GND}
N 2290 3110 2300 3110 {
lab=GND}
N 2150 3000 2290 3000 {
lab=#net414}
N 2250 3030 2250 3070 {
lab=VBIAS}
N 2110 3070 2250 3070 {
lab=VBIAS}
N 2110 3040 2110 3070 {
lab=VBIAS}
N 2250 3110 2250 3150 {
lab=VBIAS}
N 2110 3150 2250 3150 {
lab=VBIAS}
N 2110 3110 2110 3150 {
lab=VBIAS}
N 2210 2940 2210 3000 {
lab=#net414}
N 2110 3030 2110 3040 {
lab=VBIAS}
N 2090 3030 2110 3030 {
lab=VBIAS}
N 2090 3110 2110 3110 {
lab=VBIAS}
N 2340 2910 2390 2910 {
lab=#net420}
N 1940 2910 2020 2910 {
lab=#net418}
N 1940 2930 1940 2990 {
lab=#net420}
N 1940 2990 2390 2990 {
lab=#net420}
N 2390 2910 2390 2990 {
lab=#net420}
N 2840 2940 3020 2940 {
lab=#net421}
N 2840 2910 2870 2910 {
lab=GND}
N 2870 2910 2870 2960 {
lab=GND}
N 2990 2910 3020 2910 {
lab=GND}
N 2990 2910 2990 2960 {
lab=GND}
N 2840 2850 2840 2880 {
lab=#net422}
N 3020 2840 3020 2880 {
lab=#net423}
N 2870 3060 2870 3080 {
lab=#net424}
N 2870 3140 2870 3170 {
lab=GND}
N 2740 2910 2800 2910 {
lab=#net425}
N 2870 3030 2880 3030 {
lab=GND}
N 2880 3030 2880 3160 {
lab=GND}
N 2870 3160 2880 3160 {
lab=GND}
N 2870 3110 2880 3110 {
lab=GND}
N 3010 3060 3010 3080 {
lab=#net426}
N 3010 3140 3010 3170 {
lab=GND}
N 3010 3030 3020 3030 {
lab=GND}
N 3020 3030 3020 3160 {
lab=GND}
N 3010 3160 3020 3160 {
lab=GND}
N 3010 3110 3020 3110 {
lab=GND}
N 2870 3000 3010 3000 {
lab=#net421}
N 2970 3030 2970 3070 {
lab=VBIAS}
N 2830 3070 2970 3070 {
lab=VBIAS}
N 2830 3040 2830 3070 {
lab=VBIAS}
N 2970 3110 2970 3150 {
lab=VBIAS}
N 2830 3150 2970 3150 {
lab=VBIAS}
N 2830 3110 2830 3150 {
lab=VBIAS}
N 2930 2940 2930 3000 {
lab=#net421}
N 2830 3030 2830 3040 {
lab=VBIAS}
N 2810 3030 2830 3030 {
lab=VBIAS}
N 2810 3110 2830 3110 {
lab=VBIAS}
N 3060 2910 3110 2910 {
lab=#net427}
N 2660 2910 2740 2910 {
lab=#net425}
N 2660 2930 2660 2990 {
lab=#net427}
N 2660 2990 3110 2990 {
lab=#net427}
N 3110 2910 3110 2990 {
lab=#net427}
N 3550 2940 3730 2940 {
lab=#net428}
N 3550 2910 3580 2910 {
lab=GND}
N 3580 2910 3580 2960 {
lab=GND}
N 3700 2910 3730 2910 {
lab=GND}
N 3700 2910 3700 2960 {
lab=GND}
N 3550 2850 3550 2880 {
lab=#net429}
N 3730 2840 3730 2880 {
lab=#net430}
N 3580 3060 3580 3080 {
lab=#net431}
N 3580 3140 3580 3170 {
lab=GND}
N 3450 2910 3510 2910 {
lab=#net432}
N 3580 3030 3590 3030 {
lab=GND}
N 3590 3030 3590 3160 {
lab=GND}
N 3580 3160 3590 3160 {
lab=GND}
N 3580 3110 3590 3110 {
lab=GND}
N 3720 3060 3720 3080 {
lab=#net433}
N 3720 3140 3720 3170 {
lab=GND}
N 3720 3030 3730 3030 {
lab=GND}
N 3730 3030 3730 3160 {
lab=GND}
N 3720 3160 3730 3160 {
lab=GND}
N 3720 3110 3730 3110 {
lab=GND}
N 3580 3000 3720 3000 {
lab=#net428}
N 3680 3030 3680 3070 {
lab=VBIAS}
N 3540 3070 3680 3070 {
lab=VBIAS}
N 3540 3040 3540 3070 {
lab=VBIAS}
N 3680 3110 3680 3150 {
lab=VBIAS}
N 3540 3150 3680 3150 {
lab=VBIAS}
N 3540 3110 3540 3150 {
lab=VBIAS}
N 3640 2940 3640 3000 {
lab=#net428}
N 3540 3030 3540 3040 {
lab=VBIAS}
N 3520 3030 3540 3030 {
lab=VBIAS}
N 3520 3110 3540 3110 {
lab=VBIAS}
N 3770 2910 3820 2910 {
lab=#net434}
N 3370 2910 3450 2910 {
lab=#net432}
N 3370 2930 3370 2990 {
lab=#net434}
N 3370 2990 3820 2990 {
lab=#net434}
N 3820 2910 3820 2990 {
lab=#net434}
N 4260 2940 4440 2940 {
lab=#net435}
N 4260 2910 4290 2910 {
lab=GND}
N 4290 2910 4290 2960 {
lab=GND}
N 4410 2910 4440 2910 {
lab=GND}
N 4410 2910 4410 2960 {
lab=GND}
N 4260 2850 4260 2880 {
lab=#net436}
N 4440 2840 4440 2880 {
lab=#net437}
N 4290 3060 4290 3080 {
lab=#net438}
N 4290 3140 4290 3170 {
lab=GND}
N 4160 2910 4220 2910 {
lab=#net439}
N 4290 3030 4300 3030 {
lab=GND}
N 4300 3030 4300 3160 {
lab=GND}
N 4290 3160 4300 3160 {
lab=GND}
N 4290 3110 4300 3110 {
lab=GND}
N 4430 3060 4430 3080 {
lab=#net440}
N 4430 3140 4430 3170 {
lab=GND}
N 4430 3030 4440 3030 {
lab=GND}
N 4440 3030 4440 3160 {
lab=GND}
N 4430 3160 4440 3160 {
lab=GND}
N 4430 3110 4440 3110 {
lab=GND}
N 4290 3000 4430 3000 {
lab=#net435}
N 4390 3030 4390 3070 {
lab=VBIAS}
N 4250 3070 4390 3070 {
lab=VBIAS}
N 4250 3040 4250 3070 {
lab=VBIAS}
N 4390 3110 4390 3150 {
lab=VBIAS}
N 4250 3150 4390 3150 {
lab=VBIAS}
N 4250 3110 4250 3150 {
lab=VBIAS}
N 4350 2940 4350 3000 {
lab=#net435}
N 4250 3030 4250 3040 {
lab=VBIAS}
N 4230 3030 4250 3030 {
lab=VBIAS}
N 4230 3110 4250 3110 {
lab=VBIAS}
N 4480 2910 4530 2910 {
lab=#net441}
N 4080 2910 4160 2910 {
lab=#net439}
N 4080 2930 4080 2990 {
lab=#net441}
N 4080 2990 4530 2990 {
lab=#net441}
N -930 -310 -840 -310 {
lab=D7}
N -930 -330 -840 -330 {
lab=D6}
N -930 -350 -840 -350 {
lab=D5}
N -930 -370 -840 -370 {
lab=D4}
N -930 -390 -840 -390 {
lab=D3}
N -930 -410 -840 -410 {
lab=D2}
N -930 -430 -840 -430 {
lab=D1}
N 180 -840 180 -750 {
lab=C7}
N 160 -840 160 -750 {
lab=C6}
N 140 -840 140 -750 {
lab=C5}
N 120 -840 120 -750 {
lab=C4}
N 100 -840 100 -750 {
lab=C3}
N 80 -840 80 -750 {
lab=C2}
N 60 -840 60 -750 {
lab=C1}
N -540 -400 -440 -400 {
lab=D1}
N -540 -380 -440 -380 {
lab=C1}
N 250 -400 320 -400 {
lab=D1}
N 990 -400 1020 -400 {
lab=D1}
N 1690 -400 1750 -400 {
lab=D1}
N 2420 -400 2470 -400 {
lab=D1}
N 3140 -400 3180 -400 {
lab=D1}
N 3140 -400 3180 -400 {
lab=D1}
N 3850 -400 3890 -400 {
lab=D1}
N 3850 -400 3890 -400 {
lab=D1}
N 4550 -400 4590 -400 {
lab=D1}
N 4550 -400 4590 -400 {
lab=D1}
N 260 -380 320 -380 {
lab=C2}
N 990 -380 1020 -380 {
lab=C3}
N 1700 -380 1750 -380 {
lab=C4}
N 3150 -380 3180 -380 {
lab=C6}
N 3860 -380 3890 -380 {
lab=C7}
N 4570 -380 4590 -380 {
lab=GND}
N -460 40 -440 40 {
lab=D1}
N -460 60 -440 60 {
lab=D2}
N 290 40 320 40 {
lab=D1}
N 290 60 320 60 {
lab=D2}
N 990 40 1020 40 {
lab=D1}
N 990 60 1020 60 {
lab=D2}
N 1710 40 1750 40 {
lab=D1}
N 1710 60 1750 60 {
lab=D2}
N 2430 40 2470 40 {
lab=D1}
N 2430 60 2470 60 {
lab=D2}
N 3140 40 3180 40 {
lab=D1}
N 3140 60 3180 60 {
lab=D2}
N 3850 40 3890 40 {
lab=D1}
N 3850 60 3890 60 {
lab=D2}
N 4560 60 4590 60 {
lab=D1}
N 4560 80 4590 80 {
lab=D2}
N 4570 100 4590 100 {
lab=GND}
N -460 80 -440 80 {
lab=C1}
N 290 80 320 80 {
lab=C2}
N 990 80 1020 80 {
lab=C3}
N 1700 80 1750 80 {
lab=C4}
N 2430 -380 2470 -380 {
lab=C5}
N 2430 80 2470 80 {
lab=C5}
N 3150 80 3180 80 {
lab=C6}
N 3860 80 3890 80 {
lab=C7}
N -480 490 -440 490 {
lab=D2}
N -480 510 -440 510 {
lab=D3}
N -480 530 -440 530 {
lab=C1}
N 280 490 320 490 {
lab=D2}
N 280 510 320 510 {
lab=D3}
N 280 530 320 530 {
lab=C2}
N 990 490 1020 490 {
lab=D2}
N 990 510 1020 510 {
lab=D3}
N 990 530 1020 530 {
lab=C3}
N 1710 490 1750 490 {
lab=D2}
N 1710 510 1750 510 {
lab=D3}
N 1710 530 1750 530 {
lab=C4}
N 2440 490 2470 490 {
lab=D2}
N 2440 510 2470 510 {
lab=D3}
N 2440 530 2470 530 {
lab=C5}
N 3140 490 3180 490 {
lab=D2}
N 3140 510 3180 510 {
lab=D3}
N 3140 530 3180 530 {
lab=C6}
N 3850 490 3890 490 {
lab=D2}
N 3850 510 3890 510 {
lab=D3}
N 3850 530 3890 530 {
lab=C7}
N 4560 490 4590 490 {
lab=D2}
N 4560 510 4590 510 {
lab=D3}
N 4570 530 4590 530 {
lab=GND}
N -480 1000 -440 1000 {
lab=D3}
N -480 1020 -440 1020 {
lab=D4}
N -480 1040 -440 1040 {
lab=C1}
N 280 1000 320 1000 {
lab=D3}
N 280 1020 320 1020 {
lab=D4}
N 280 1040 320 1040 {
lab=C2}
N 990 1000 1020 1000 {
lab=D3}
N 990 1020 1020 1020 {
lab=D4}
N 990 1040 1020 1040 {
lab=C3}
N 1720 1000 1750 1000 {
lab=D3}
N 1720 1020 1750 1020 {
lab=D4}
N 1720 1040 1750 1040 {
lab=C4}
N 2440 1000 2470 1000 {
lab=D3}
N 2440 1020 2470 1020 {
lab=D4}
N 2440 1040 2470 1040 {
lab=C5}
N 3150 1000 3180 1000 {
lab=D3}
N 3150 1020 3180 1020 {
lab=D4}
N 3150 1040 3180 1040 {
lab=C6}
N 3860 1000 3890 1000 {
lab=D3}
N 3860 1020 3890 1020 {
lab=D4}
N 3860 1040 3890 1040 {
lab=C7}
N 4560 1000 4590 1000 {
lab=D3}
N 4560 1020 4590 1020 {
lab=D4}
N 4570 1040 4590 1040 {
lab=GND}
N -480 1470 -440 1470 {
lab=D4}
N -480 1490 -440 1490 {
lab=D5}
N -480 1510 -440 1510 {
lab=C1}
N 280 1470 320 1470 {
lab=D4}
N 280 1490 320 1490 {
lab=D5}
N 280 1510 320 1510 {
lab=C2}
N 1000 1470 1020 1470 {
lab=D4}
N 1000 1490 1020 1490 {
lab=D5}
N 1000 1510 1020 1510 {
lab=C3}
N 1730 1470 1750 1470 {
lab=D4}
N 1730 1490 1750 1490 {
lab=D5}
N 1730 1510 1750 1510 {
lab=C4}
N 2450 1470 2470 1470 {
lab=D4}
N 2450 1490 2470 1490 {
lab=D5}
N 2450 1510 2470 1510 {
lab=C5}
N 3160 1470 3180 1470 {
lab=D4}
N 3160 1490 3180 1490 {
lab=D5}
N 3160 1510 3180 1510 {
lab=C6}
N 3870 1470 3890 1470 {
lab=D4}
N 3870 1490 3890 1490 {
lab=D5}
N 3870 1510 3890 1510 {
lab=C7}
N 4570 1470 4590 1470 {
lab=D4}
N 4570 1490 4590 1490 {
lab=D5}
N 4570 1510 4590 1510 {
lab=GND}
N -480 1970 -440 1970 {
lab=D5}
N -480 1990 -440 1990 {
lab=D6}
N -480 2010 -440 2010 {
lab=C1}
N 280 1970 320 1970 {
lab=D5}
N 280 1990 320 1990 {
lab=D6}
N 280 2010 320 2010 {
lab=C2}
N 980 1970 1020 1970 {
lab=D5}
N 980 1990 1020 1990 {
lab=D6}
N 980 2010 1020 2010 {
lab=C3}
N 1710 1970 1750 1970 {
lab=D5}
N 1710 1990 1750 1990 {
lab=D6}
N 1710 2010 1750 2010 {
lab=C4}
N 2430 1970 2470 1970 {
lab=D5}
N 2430 1990 2470 1990 {
lab=D6}
N 2430 2010 2470 2010 {
lab=C5}
N 3140 1970 3180 1970 {
lab=D5}
N 3140 1990 3180 1990 {
lab=D6}
N 3140 2010 3180 2010 {
lab=C6}
N 3850 1970 3890 1970 {
lab=D5}
N 3850 1990 3890 1990 {
lab=D6}
N 3850 2010 3890 2010 {
lab=C7}
N 4550 1970 4590 1970 {
lab=D5}
N 4550 1990 4590 1990 {
lab=D6}
N 4550 2010 4590 2010 {
lab=GND}
N -480 2430 -440 2430 {
lab=D6}
N -480 2450 -440 2450 {
lab=D7}
N -480 2470 -440 2470 {
lab=C1}
N 280 2430 320 2430 {
lab=D6}
N 280 2450 320 2450 {
lab=D7}
N 280 2470 320 2470 {
lab=C2}
N 980 2430 1020 2430 {
lab=D6}
N 980 2450 1020 2450 {
lab=D7}
N 980 2470 1020 2470 {
lab=C3}
N 1710 2430 1750 2430 {
lab=D6}
N 1710 2450 1750 2450 {
lab=D7}
N 1710 2470 1750 2470 {
lab=C4}
N 2430 2430 2470 2430 {
lab=D6}
N 2430 2450 2470 2450 {
lab=D7}
N 2430 2470 2470 2470 {
lab=C5}
N 3140 2430 3180 2430 {
lab=D6}
N 3140 2450 3180 2450 {
lab=D7}
N 3140 2470 3180 2470 {
lab=C6}
N 3850 2430 3890 2430 {
lab=D6}
N 3850 2450 3890 2450 {
lab=D7}
N 3850 2470 3890 2470 {
lab=C7}
N 4550 2430 4590 2430 {
lab=D6}
N 4550 2450 4590 2450 {
lab=D7}
N 4550 2470 4590 2470 {
lab=GND}
N -480 2890 -440 2890 {
lab=D7}
N -480 2930 -440 2930 {
lab=C1}
N -460 2910 -440 2910 {
lab=GND}
N 290 2890 330 2890 {
lab=D7}
N 290 2930 330 2930 {
lab=C2}
N 310 2910 330 2910 {
lab=GND}
N 980 2890 1020 2890 {
lab=D7}
N 980 2930 1020 2930 {
lab=C3}
N 1000 2910 1020 2910 {
lab=GND}
N 1710 2890 1750 2890 {
lab=D7}
N 1710 2930 1750 2930 {
lab=C4}
N 1730 2910 1750 2910 {
lab=GND}
N 2430 2890 2470 2890 {
lab=D7}
N 2430 2930 2470 2930 {
lab=C5}
N 2450 2910 2470 2910 {
lab=GND}
N 3140 2890 3180 2890 {
lab=D7}
N 3140 2930 3180 2930 {
lab=C6}
N 3160 2910 3180 2910 {
lab=GND}
N 3850 2890 3890 2890 {
lab=D7}
N 3850 2930 3890 2930 {
lab=C7}
N 3870 2910 3890 2910 {
lab=GND}
N 4530 2910 4530 2990 {
lab=#net441}
N -480 2950 -440 2950 {
lab=CLK}
N 290 2950 320 2950 {
lab=CLK}
N 990 2950 1020 2950 {
lab=CLK}
N 1710 2950 1750 2950 {
lab=CLK}
N 2440 2950 2470 2950 {
lab=CLK}
N 3150 2950 3180 2950 {
lab=CLK}
N 3860 2950 3890 2950 {
lab=CLK}
N -480 2490 -440 2490 {
lab=CLK}
N 280 2490 320 2490 {
lab=CLK}
N 980 2490 1020 2490 {
lab=CLK}
N 1710 2490 1750 2490 {
lab=CLK}
N 2430 2490 2470 2490 {
lab=CLK}
N 3140 2490 3180 2490 {
lab=CLK}
N 3850 2490 3890 2490 {
lab=CLK}
N 4550 2490 4590 2490 {
lab=CLK}
N 4560 2470 4560 2520 {
lab=GND}
N -480 2030 -440 2030 {
lab=CLK}
N 280 2030 320 2030 {
lab=CLK}
N 980 2030 1020 2030 {
lab=CLK}
N 1710 2030 1750 2030 {
lab=CLK}
N 2430 2030 2470 2030 {
lab=CLK}
N 3140 2030 3180 2030 {
lab=CLK}
N 3850 2030 3890 2030 {
lab=CLK}
N 4550 2030 4590 2030 {
lab=CLK}
N 4550 1530 4590 1530 {
lab=CLK}
N 3850 1530 3890 1530 {
lab=CLK}
N 3140 1530 3180 1530 {
lab=CLK}
N 2430 1530 2470 1530 {
lab=CLK}
N 1710 1530 1750 1530 {
lab=CLK}
N 980 1530 1020 1530 {
lab=CLK}
N 280 1530 320 1530 {
lab=CLK}
N -480 1530 -440 1530 {
lab=CLK}
N -480 1060 -440 1060 {
lab=CLK}
N 280 1060 320 1060 {
lab=CLK}
N 980 1060 1020 1060 {
lab=CLK}
N 1710 1060 1750 1060 {
lab=CLK}
N 2430 1060 2470 1060 {
lab=CLK}
N 3140 1060 3180 1060 {
lab=CLK}
N 3850 1060 3890 1060 {
lab=CLK}
N 4550 1060 4590 1060 {
lab=CLK}
N 3860 1060 3900 1060 {
lab=CLK}
N 4560 550 4590 550 {
lab=CLK}
N 3850 550 3890 550 {
lab=CLK}
N 3140 550 3180 550 {
lab=CLK}
N 2430 550 2470 550 {
lab=CLK}
N 1710 550 1750 550 {
lab=CLK}
N 980 550 1020 550 {
lab=CLK}
N 280 550 320 550 {
lab=CLK}
N -480 550 -440 550 {
lab=CLK}
N -480 100 -440 100 {
lab=CLK}
N 280 100 320 100 {
lab=CLK}
N 980 100 1020 100 {
lab=CLK}
N 1710 100 1750 100 {
lab=CLK}
N 2430 100 2470 100 {
lab=CLK}
N 3140 100 3180 100 {
lab=CLK}
N 3850 100 3890 100 {
lab=CLK}
N 4550 120 4590 120 {
lab=CLK}
N 4570 100 4570 150 {
lab=GND}
N -470 2910 -460 2910 {
lab=GND}
N -470 2910 -470 2990 {
lab=GND}
N 300 2910 300 2980 {
lab=GND}
N 300 2910 310 2910 {
lab=GND}
N 1000 2910 1000 3000 {
lab=GND}
N 1720 2910 1720 3000 {
lab=GND}
N 1720 2910 1730 2910 {
lab=GND}
N 2450 2910 2450 3000 {
lab=GND}
N 3160 2910 3160 2990 {
lab=GND}
N 3870 2910 3870 2980 {
lab=GND}
N -70 -660 -70 -520 {
lab=Q5}
N 5450 -780 5450 -660 {
lab=Q5}
N 110 -600 110 -530 {
lab=#net443}
N 100 -600 5590 -600 {
lab=#net443}
N 5600 -780 5600 -600 {
lab=#net443}
N 690 -660 690 -520 {
lab=Q5}
N 1390 -660 1390 -520 {
lab=Q5}
N 870 -600 870 -530 {
lab=#net443}
N 1570 -600 1570 -530 {
lab=#net443}
N 2120 -660 2120 -520 {
lab=Q5}
N 2300 -600 2300 -530 {
lab=#net443}
N 2840 -650 2840 -520 {
lab=Q5}
N 2840 -660 2840 -650 {
lab=Q5}
N 3020 -600 3020 -530 {
lab=#net443}
N 3550 -660 3550 -520 {
lab=Q5}
N 3730 -600 3730 -530 {
lab=#net443}
N 4260 -660 4260 -520 {
lab=Q5}
N 4440 -600 4440 -530 {
lab=#net443}
N 4960 -660 4960 -520 {
lab=Q5}
N 5140 -600 5140 -530 {
lab=#net443}
N 5450 -960 5450 -840 {
lab=xxx}
N 5600 -960 5600 -840 {
lab=xxx}
N -1280 -290 -1230 -290 {
lab=X8}
N -1280 -310 -1230 -310 {
lab=X9}
N -1280 -330 -1230 -330 {
lab=X10}
N 200 -1200 200 -1140 {
lab=X5}
N 180 -1200 180 -1140 {
lab=X6}
N 160 -1200 160 -1140 {
lab=X7}
N -70 -110 -70 -60 {
lab=Q5}
N -70 -110 610 -110 {
lab=Q5}
N 110 -70 600 -70 {
lab=#net443}
N 600 -70 5850 -70 {
lab=#net443}
N 870 -70 870 -60 {
lab=#net443}
N 1570 -70 1570 -60 {
lab=#net443}
N 2300 -70 2300 -50 {
lab=#net443}
N 3020 -70 3020 -60 {
lab=#net443}
N 3730 -70 3730 -60 {
lab=#net443}
N 4440 -70 4440 -50 {
lab=#net443}
N 5140 -70 5140 -40 {
lab=#net443}
N 610 -110 5770 -110 {
lab=Q5}
N 4960 -110 4960 -40 {
lab=Q5}
N 4260 -110 4260 -50 {
lab=Q5}
N 3550 -110 3550 -50 {
lab=Q5}
N 2840 -110 2840 -60 {
lab=Q5}
N 2120 -110 2120 -60 {
lab=Q5}
N 1390 -110 1390 -60 {
lab=Q5}
N 690 -110 690 -60 {
lab=Q5}
N 110 370 110 380 {
lab=#net443}
N 110 370 5650 370 {
lab=#net443}
N 5140 370 5140 380 {
lab=#net443}
N 4440 370 4440 380 {
lab=#net443}
N 3730 370 3730 380 {
lab=#net443}
N 3020 370 3020 380 {
lab=#net443}
N 2300 370 2300 380 {
lab=#net443}
N 1570 370 1570 380 {
lab=#net443}
N 870 370 870 380 {
lab=#net443}
N -70 350 -70 390 {
lab=Q5}
N -70 350 5640 350 {
lab=Q5}
N 4890 330 4990 330 {
lab=GND}
N 4890 300 4890 330 {
lab=GND}
N 4850 300 4890 300 {
lab=GND}
N 5170 320 5210 320 {
lab=GND}
N 5170 320 5170 340 {
lab=GND}
N 5130 340 5170 340 {
lab=GND}
N 690 350 690 390 {
lab=Q5}
N 1390 350 1390 390 {
lab=Q5}
N 2120 350 2120 390 {
lab=Q5}
N 2840 350 2840 390 {
lab=Q5}
N 3550 350 3550 390 {
lab=Q5}
N 4260 350 4260 390 {
lab=Q5}
N 4960 350 4960 390 {
lab=Q5}
N 110 870 110 890 {
lab=#net443}
N 110 870 5580 870 {
lab=#net443}
N 5140 870 5140 890 {
lab=#net443}
N 4440 870 4440 890 {
lab=#net443}
N 3730 870 3730 890 {
lab=#net443}
N 3020 870 3020 890 {
lab=#net443}
N 2300 870 2300 890 {
lab=#net443}
N 1570 870 1570 890 {
lab=#net443}
N 870 870 870 890 {
lab=#net443}
N -70 840 -70 900 {
lab=Q5}
N -70 840 5580 840 {
lab=Q5}
N 4960 840 4960 900 {
lab=Q5}
N 4260 840 4260 900 {
lab=Q5}
N 3550 840 3550 900 {
lab=Q5}
N 2840 840 2840 900 {
lab=Q5}
N 2120 840 2120 900 {
lab=Q5}
N 1390 840 1390 900 {
lab=Q5}
N 690 840 690 900 {
lab=Q5}
N 110 1350 110 1360 {
lab=#net443}
N 110 1350 5510 1350 {
lab=#net443}
N 5140 1350 5140 1360 {
lab=#net443}
N 4440 1350 4440 1360 {
lab=#net443}
N 3730 1350 3730 1360 {
lab=#net443}
N 3020 1350 3020 1360 {
lab=#net443}
N 2300 1350 2300 1360 {
lab=#net443}
N 1570 1350 1570 1360 {
lab=#net443}
N 870 1350 870 1360 {
lab=#net443}
N -70 1330 -70 1370 {
lab=Q5}
N -70 1330 5510 1330 {
lab=Q5}
N 4960 1330 4960 1370 {
lab=Q5}
N 4260 1330 4260 1370 {
lab=Q5}
N 3550 1330 3550 1370 {
lab=Q5}
N 2840 1330 2840 1370 {
lab=Q5}
N 2120 1330 2120 1370 {
lab=Q5}
N 1390 1330 1390 1370 {
lab=Q5}
N 690 1330 690 1370 {
lab=Q5}
N 110 1840 110 1860 {
lab=#net443}
N 110 1840 5630 1840 {
lab=#net443}
N 5140 1840 5140 1860 {
lab=#net443}
N 4440 1840 4440 1860 {
lab=#net443}
N 3730 1840 3730 1860 {
lab=#net443}
N 3020 1840 3020 1860 {
lab=#net443}
N 2300 1840 2300 1860 {
lab=#net443}
N 1570 1840 1570 1860 {
lab=#net443}
N 870 1840 870 1860 {
lab=#net443}
N -70 1800 -70 1870 {
lab=Q5}
N -70 1800 5630 1800 {
lab=Q5}
N 4960 1800 4960 1870 {
lab=Q5}
N 4260 1800 4260 1870 {
lab=Q5}
N 3550 1800 3550 1870 {
lab=Q5}
N 2840 1800 2840 1870 {
lab=Q5}
N 2120 1800 2120 1870 {
lab=Q5}
N 1390 1800 1390 1870 {
lab=Q5}
N 690 1800 690 1870 {
lab=Q5}
N 110 2310 110 2320 {
lab=#net443}
N 110 2310 5510 2310 {
lab=#net443}
N 5140 2310 5140 2320 {
lab=#net443}
N 4440 2310 4440 2320 {
lab=#net443}
N 3730 2310 3730 2320 {
lab=#net443}
N 3020 2310 3020 2320 {
lab=#net443}
N 2300 2310 2300 2320 {
lab=#net443}
N 1570 2310 1570 2320 {
lab=#net443}
N 870 2310 870 2320 {
lab=#net443}
N -70 2290 -70 2330 {
lab=Q5}
N -70 2290 5500 2290 {
lab=Q5}
N 4960 2290 4960 2330 {
lab=Q5}
N 4260 2290 4260 2330 {
lab=Q5}
N 3550 2290 3550 2330 {
lab=Q5}
N 2840 2290 2840 2330 {
lab=Q5}
N 2120 2290 2120 2330 {
lab=Q5}
N 1390 2290 1390 2330 {
lab=Q5}
N 690 2290 690 2330 {
lab=Q5}
N 110 2770 110 2780 {
lab=#net443}
N 110 2770 5620 2770 {
lab=#net443}
N 4440 2770 4440 2780 {
lab=#net443}
N 3730 2770 3730 2780 {
lab=#net443}
N 3020 2770 3020 2780 {
lab=#net443}
N 2300 2770 2300 2780 {
lab=#net443}
N 1570 2770 1570 2780 {
lab=#net443}
N 870 2770 870 2780 {
lab=#net443}
N -70 2750 -70 2790 {
lab=Q5}
N -70 2750 5610 2750 {
lab=Q5}
N 4260 2750 4260 2790 {
lab=Q5}
N 3550 2750 3550 2790 {
lab=Q5}
N 2840 2750 2840 2790 {
lab=Q5}
N 2120 2750 2120 2790 {
lab=Q5}
N 1390 2750 1390 2790 {
lab=Q5}
N 690 2750 690 2790 {
lab=Q5}
N 5770 -660 5770 -110 {
lab=Q5}
N 5850 -600 5850 -70 {
lab=#net443}
N 5640 -660 5640 350 {
lab=Q5}
N 5650 370 5860 370 {
lab=#net443}
N 5860 370 5980 370 {
lab=#net443}
N 5980 -600 5980 370 {
lab=#net443}
N 5580 840 6110 840 {
lab=Q5}
N 6110 -660 6110 840 {
lab=Q5}
N 5580 870 6050 870 {
lab=#net443}
N 6050 -600 6050 870 {
lab=#net443}
N 5510 1330 6180 1330 {
lab=Q5}
N 5510 1350 6290 1350 {
lab=#net443}
N 6180 1330 6210 1330 {
lab=Q5}
N 6210 1230 6210 1330 {
lab=Q5}
N 6290 1230 6290 1350 {
lab=#net443}
N 6210 -660 6210 1230 {
lab=Q5}
N 6290 -600 6290 1230 {
lab=#net443}
N 5630 1800 6480 1800 {
lab=Q5}
N 5500 2290 6520 2290 {
lab=Q5}
N 6520 1800 6520 2290 {
lab=Q5}
N 5610 2750 6600 2750 {
lab=Q5}
N 6600 1800 6600 2750 {
lab=Q5}
N 6480 1800 6600 1800 {
lab=Q5}
N 6520 -660 6520 1800 {
lab=Q5}
N 5630 1840 6240 1840 {
lab=#net443}
N 5510 2310 6340 2310 {
lab=#net443}
N 5620 2770 6440 2770 {
lab=#net443}
N 6440 1840 6440 2770 {
lab=#net443}
N 6340 1840 6340 2310 {
lab=#net443}
N 6240 1840 6440 1840 {
lab=#net443}
N 6340 -600 6340 1840 {
lab=#net443}
N 4990 310 4990 330 {
lab=GND}
N 4570 530 4570 580 {
lab=GND}
N 5450 -660 6520 -660 {
lab=Q5}
N 5600 -600 6340 -600 {
lab=#net443}
N 9260 -10 9620 -10 {
lab=#net444}
N 9620 -260 9620 -70 {
lab=#net445}
N 9260 -270 9260 -70 {
lab=#net446}
N 9570 -40 9620 -40 {
lab=GND}
N 9620 -390 9620 -320 {
lab=Q5}
N 9260 -410 9260 -330 {
lab=#net443}
N 9620 -410 9620 -390 {
lab=Q5}
N 9570 -40 9570 30 {
lab=GND}
N 9300 -40 9300 20 {
lab=GND}
N 9430 170 9430 200 {
lab=#net447}
N 9470 230 9530 230 {
lab=VBIAS}
N 9370 140 9370 230 {
lab=GND}
N 9370 230 9430 230 {
lab=GND}
N 9470 140 9530 140 {
lab=VBIAS}
N 9370 140 9430 140 {
lab=GND}
N 9430 -10 9430 110 {
lab=#net444}
N 9430 260 9430 300 {
lab=GND}
N 9370 230 9370 280 {
lab=GND}
N 9370 280 9430 280 {
lab=GND}
N 8450 -10 8810 -10 {
lab=#net448}
N 8760 -40 8810 -40 {
lab=GND}
N 8450 -40 8490 -40 {
lab=GND}
N 8760 -40 8760 30 {
lab=GND}
N 8490 -40 8490 20 {
lab=GND}
N 8620 170 8620 200 {
lab=#net449}
N 8660 230 8720 230 {
lab=VBIAS}
N 8560 140 8560 230 {
lab=GND}
N 8560 230 8620 230 {
lab=GND}
N 8660 140 8720 140 {
lab=VBIAS}
N 8560 140 8620 140 {
lab=GND}
N 8620 -10 8620 110 {
lab=#net448}
N 8620 260 8620 300 {
lab=GND}
N 8560 230 8560 280 {
lab=GND}
N 8560 280 8620 280 {
lab=GND}
N 8810 -170 8810 -70 {
lab=#net450}
N 8450 -170 8450 -70 {
lab=#net451}
N 8810 -410 8810 -230 {
lab=Q5}
N 8450 -410 8450 -230 {
lab=#net443}
N 7660 -10 8020 -10 {
lab=#net452}
N 7970 -40 8020 -40 {
lab=GND}
N 7660 -40 7700 -40 {
lab=GND}
N 7970 -40 7970 30 {
lab=GND}
N 7700 -40 7700 20 {
lab=GND}
N 7920 140 7920 170 {
lab=#net453}
N 7960 200 8020 200 {
lab=VBIAS}
N 7860 110 7860 200 {
lab=GND}
N 7860 200 7920 200 {
lab=GND}
N 7960 110 8020 110 {
lab=VBIAS}
N 7860 110 7920 110 {
lab=GND}
N 7920 230 7920 270 {
lab=GND}
N 7860 200 7860 250 {
lab=GND}
N 7860 250 7920 250 {
lab=GND}
N 8020 -170 8020 -70 {
lab=#net454}
N 7660 -170 7660 -70 {
lab=#net455}
N 8020 -410 8020 -230 {
lab=Q5}
N 7660 -410 7660 -230 {
lab=#net443}
N 7740 140 7740 170 {
lab=#net456}
N 7680 110 7680 200 {
lab=GND}
N 7680 200 7740 200 {
lab=GND}
N 7680 110 7740 110 {
lab=GND}
N 7740 230 7740 270 {
lab=GND}
N 7680 200 7680 250 {
lab=GND}
N 7680 250 7740 250 {
lab=GND}
N 7740 80 7920 80 {
lab=#net452}
N 7830 -10 7830 80 {
lab=#net452}
N 7780 150 7990 150 {
lab=VBIAS}
N 7990 110 7990 150 {
lab=VBIAS}
N 7780 110 7780 150 {
lab=VBIAS}
N 7990 200 7990 240 {
lab=VBIAS}
N 7780 240 7990 240 {
lab=VBIAS}
N 7780 200 7780 240 {
lab=VBIAS}
N 9260 -40 9300 -40 {
lab=GND}
N 9220 -40 9220 500 {
lab=Q1}
N 9220 500 9430 500 {
lab=Q1}
N 8410 -40 8410 470 {
lab=Q2}
N 8410 470 8600 470 {
lab=Q2}
N 7560 -40 7560 450 {
lab=Q3}
N 7560 450 7800 450 {
lab=Q3}
N 7560 -40 7620 -40 {
lab=Q3}
N 8060 -40 8120 -40 {
lab=negQ3}
N 9620 -660 9620 -410 {
lab=Q5}
N 6770 -660 9620 -660 {
lab=Q5}
N 7290 -660 7290 -410 {
lab=Q5}
N 8020 -660 8020 -410 {
lab=Q5}
N 8810 -660 8810 -410 {
lab=Q5}
N 9260 -590 9260 -410 {
lab=#net443}
N 6780 -590 9260 -590 {
lab=#net443}
N 8450 -590 8450 -410 {
lab=#net443}
N 7660 -590 7660 -410 {
lab=#net443}
N 6930 -590 6930 -410 {
lab=#net443}
N 6930 -10 7290 -10 {
lab=#net457}
N 7260 -40 7290 -40 {
lab=GND}
N 7260 -40 7260 10 {
lab=GND}
N 6930 -40 6960 -40 {
lab=GND}
N 6960 -40 6960 10 {
lab=GND}
N 7290 -150 7290 -70 {
lab=#net458}
N 6930 -150 6930 -70 {
lab=#net459}
N 7290 -310 7290 -210 {
lab=Q5}
N 7090 50 7090 110 {
lab=#net457}
N 7090 50 7090 110 {
lab=#net457}
N 6970 140 7090 140 {
lab=GND}
N 7090 170 7090 190 {
lab=#net460}
N 7130 140 7180 140 {
lab=VBIAS}
N 7010 220 7090 220 {
lab=GND}
N 6970 220 7010 220 {
lab=GND}
N 7090 250 7090 280 {
lab=GND}
N 7130 220 7180 220 {
lab=VBIAS}
N 7090 50 7090 110 {
lab=#net457}
N 6930 -410 6930 -210 {
lab=#net443}
N 7290 -410 7290 -310 {
lab=Q5}
N 7090 -10 7090 50 {
lab=#net457}
N 7330 -40 7390 -40 {
lab=negQ4}
N 6840 -40 6890 -40 {
lab=Q4}
N 6840 -40 6840 450 {
lab=Q4}
N 6840 450 7070 450 {
lab=Q4}
N 9430 500 9430 530 {
lab=Q1}
N 9460 470 9660 470 {
lab=negQ1}
N 9450 530 9460 530 {
lab=negQ1}
N 9660 -40 9660 470 {
lab=negQ1}
N 8600 470 8600 500 {
lab=Q2}
N 8620 440 8850 440 {
lab=negQ2}
N 8850 -40 8850 440 {
lab=negQ2}
N 7820 480 7830 480 {
lab=negQ3}
N 7800 450 7800 480 {
lab=Q3}
N 7830 420 8120 420 {
lab=negQ3}
N 8120 -40 8120 420 {
lab=negQ3}
N 7070 450 7070 480 {
lab=Q4}
N 7100 420 7390 420 {
lab=negQ4}
N 7390 -40 7390 420 {
lab=negQ4}
N 5590 -600 5600 -600 {
lab=#net443}
N 7090 420 7090 480 {
lab=negQ4}
N 7090 420 7100 420 {
lab=negQ4}
N 7830 420 7830 480 {
lab=negQ3}
N 8620 440 8620 500 {
lab=negQ2}
N 9460 470 9460 530 {
lab=negQ1}
N 6780 -600 6780 -590 {
lab=#net443}
N 6340 -600 6780 -600 {
lab=#net443}
N 6520 -660 6770 -660 {
lab=Q5}
N -70 -660 5450 -660 {
lab=Q5}
C {res.sym} -70 -490 0 0 {name=R9
value=500
footprint=1206
device=resistor
m=1}
C {res.sym} 110 -500 0 0 {name=R10
value=500
footprint=1206
device=resistor
m=1}
C {symbols/nfet_03v3.sym} -90 -400 0 0 {name=M19
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 130 -400 0 1 {name=M20
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} -40 -350 0 0 {name=l27 lab=GND}
C {gnd.sym} 80 -350 0 0 {name=l28 lab=GND}
C {gnd.sym} -40 -140 0 0 {name=l30 lab=GND}
C {symbols/nfet_03v3.sym} -60 -200 0 0 {name=M21
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} -100 -280 0 0 {name=p42 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} -100 -200 0 0 {name=p43 sig_type=std_logic lab=VBIAS}
C {gnd.sym} 100 -140 0 0 {name=l31 lab=GND}
C {symbols/nfet_03v3.sym} -60 -280 0 0 {name=M23
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 80 -280 0 0 {name=M24
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 80 -200 0 0 {name=M22
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {Local_encoder.sym} -290 -390 0 0 {name=x1}
C {res.sym} 690 -490 0 0 {name=R1
value=500
footprint=1206
device=resistor
m=1}
C {res.sym} 870 -500 0 0 {name=R2
value=500
footprint=1206
device=resistor
m=1}
C {symbols/nfet_03v3.sym} 670 -400 0 0 {name=M1
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 890 -400 0 1 {name=M2
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 720 -350 0 0 {name=l1 lab=GND}
C {gnd.sym} 840 -350 0 0 {name=l2 lab=GND}
C {gnd.sym} 720 -140 0 0 {name=l3 lab=GND}
C {symbols/nfet_03v3.sym} 700 -200 0 0 {name=M3
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 660 -280 0 0 {name=p1 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 660 -200 0 0 {name=p2 sig_type=std_logic lab=VBIAS}
C {gnd.sym} 860 -140 0 0 {name=l4 lab=GND}
C {symbols/nfet_03v3.sym} 700 -280 0 0 {name=M4
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 840 -280 0 0 {name=M5
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 840 -200 0 0 {name=M6
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {Local_encoder.sym} 470 -390 0 0 {name=x2}
C {res.sym} 1390 -490 0 0 {name=R3
value=500
footprint=1206
device=resistor
m=1}
C {res.sym} 1570 -500 0 0 {name=R4
value=500
footprint=1206
device=resistor
m=1}
C {symbols/nfet_03v3.sym} 1370 -400 0 0 {name=M7
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 1590 -400 0 1 {name=M8
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 1420 -350 0 0 {name=l5 lab=GND}
C {gnd.sym} 1540 -350 0 0 {name=l6 lab=GND}
C {gnd.sym} 1420 -140 0 0 {name=l7 lab=GND}
C {symbols/nfet_03v3.sym} 1400 -200 0 0 {name=M9
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 1360 -280 0 0 {name=p3 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 1360 -200 0 0 {name=p4 sig_type=std_logic lab=VBIAS}
C {gnd.sym} 1560 -140 0 0 {name=l8 lab=GND}
C {symbols/nfet_03v3.sym} 1400 -280 0 0 {name=M10
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 1540 -280 0 0 {name=M11
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 1540 -200 0 0 {name=M12
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {Local_encoder.sym} 1170 -390 0 0 {name=x3}
C {res.sym} 2120 -490 0 0 {name=R5
value=500
footprint=1206
device=resistor
m=1}
C {res.sym} 2300 -500 0 0 {name=R6
value=500
footprint=1206
device=resistor
m=1}
C {symbols/nfet_03v3.sym} 2100 -400 0 0 {name=M13
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2320 -400 0 1 {name=M14
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 2150 -350 0 0 {name=l9 lab=GND}
C {gnd.sym} 2270 -350 0 0 {name=l10 lab=GND}
C {gnd.sym} 2150 -140 0 0 {name=l11 lab=GND}
C {symbols/nfet_03v3.sym} 2130 -200 0 0 {name=M15
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 2090 -280 0 0 {name=p5 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 2090 -200 0 0 {name=p6 sig_type=std_logic lab=VBIAS}
C {gnd.sym} 2290 -140 0 0 {name=l12 lab=GND}
C {symbols/nfet_03v3.sym} 2130 -280 0 0 {name=M16
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2270 -280 0 0 {name=M17
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2270 -200 0 0 {name=M18
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {Local_encoder.sym} 1900 -390 0 0 {name=x4}
C {res.sym} 2840 -490 0 0 {name=R7
value=500
footprint=1206
device=resistor
m=1}
C {res.sym} 3020 -500 0 0 {name=R8
value=500
footprint=1206
device=resistor
m=1}
C {symbols/nfet_03v3.sym} 2820 -400 0 0 {name=M25
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 3040 -400 0 1 {name=M26
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 2870 -350 0 0 {name=l13 lab=GND}
C {gnd.sym} 2990 -350 0 0 {name=l14 lab=GND}
C {gnd.sym} 2870 -140 0 0 {name=l15 lab=GND}
C {symbols/nfet_03v3.sym} 2850 -200 0 0 {name=M27
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 2810 -280 0 0 {name=p7 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 2810 -200 0 0 {name=p8 sig_type=std_logic lab=VBIAS}
C {gnd.sym} 3010 -140 0 0 {name=l16 lab=GND}
C {symbols/nfet_03v3.sym} 2850 -280 0 0 {name=M28
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2990 -280 0 0 {name=M29
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2990 -200 0 0 {name=M30
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {Local_encoder.sym} 2620 -390 0 0 {name=x5}
C {res.sym} 3550 -490 0 0 {name=R11
value=500
footprint=1206
device=resistor
m=1}
C {res.sym} 3730 -500 0 0 {name=R12
value=500
footprint=1206
device=resistor
m=1}
C {symbols/nfet_03v3.sym} 3530 -400 0 0 {name=M31
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 3750 -400 0 1 {name=M32
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 3580 -350 0 0 {name=l17 lab=GND}
C {gnd.sym} 3700 -350 0 0 {name=l18 lab=GND}
C {gnd.sym} 3580 -140 0 0 {name=l19 lab=GND}
C {symbols/nfet_03v3.sym} 3560 -200 0 0 {name=M33
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3520 -280 0 0 {name=p9 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 3520 -200 0 0 {name=p10 sig_type=std_logic lab=VBIAS}
C {gnd.sym} 3720 -140 0 0 {name=l20 lab=GND}
C {symbols/nfet_03v3.sym} 3560 -280 0 0 {name=M34
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 3700 -280 0 0 {name=M35
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 3700 -200 0 0 {name=M36
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {Local_encoder.sym} 3330 -390 0 0 {name=x6}
C {res.sym} 4260 -490 0 0 {name=R13
value=500
footprint=1206
device=resistor
m=1}
C {res.sym} 4440 -500 0 0 {name=R14
value=500
footprint=1206
device=resistor
m=1}
C {symbols/nfet_03v3.sym} 4240 -400 0 0 {name=M37
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 4460 -400 0 1 {name=M38
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 4290 -350 0 0 {name=l21 lab=GND}
C {gnd.sym} 4410 -350 0 0 {name=l22 lab=GND}
C {gnd.sym} 4290 -140 0 0 {name=l23 lab=GND}
C {symbols/nfet_03v3.sym} 4270 -200 0 0 {name=M39
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4230 -280 0 0 {name=p11 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 4230 -200 0 0 {name=p12 sig_type=std_logic lab=VBIAS}
C {gnd.sym} 4430 -140 0 0 {name=l24 lab=GND}
C {symbols/nfet_03v3.sym} 4270 -280 0 0 {name=M40
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 4410 -280 0 0 {name=M41
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 4410 -200 0 0 {name=M42
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {Local_encoder.sym} 4040 -390 0 0 {name=x7}
C {res.sym} 4960 -490 0 0 {name=R15
value=500
footprint=1206
device=resistor
m=1}
C {res.sym} 5140 -500 0 0 {name=R16
value=500
footprint=1206
device=resistor
m=1}
C {symbols/nfet_03v3.sym} 4940 -400 0 0 {name=M43
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 5160 -400 0 1 {name=M44
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 4990 -350 0 0 {name=l25 lab=GND}
C {gnd.sym} 5110 -350 0 0 {name=l26 lab=GND}
C {gnd.sym} 4990 -140 0 0 {name=l29 lab=GND}
C {symbols/nfet_03v3.sym} 4970 -200 0 0 {name=M45
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4930 -280 0 0 {name=p13 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 4930 -200 0 0 {name=p14 sig_type=std_logic lab=VBIAS}
C {gnd.sym} 5130 -140 0 0 {name=l32 lab=GND}
C {symbols/nfet_03v3.sym} 4970 -280 0 0 {name=M46
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 5110 -280 0 0 {name=M47
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 5110 -200 0 0 {name=M48
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {Local_encoder.sym} 4740 -390 0 0 {name=x8}
C {res.sym} -70 -30 0 0 {name=R17
value=500
footprint=1206
device=resistor
m=1}
C {res.sym} 110 -40 0 0 {name=R18
value=500
footprint=1206
device=resistor
m=1}
C {symbols/nfet_03v3.sym} -90 60 0 0 {name=M49
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 130 60 0 1 {name=M50
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} -40 110 0 0 {name=l33 lab=GND}
C {gnd.sym} 80 110 0 0 {name=l34 lab=GND}
C {gnd.sym} -40 310 0 0 {name=l35 lab=GND}
C {symbols/nfet_03v3.sym} -60 260 0 0 {name=M51
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} -100 180 0 0 {name=p15 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} -100 260 0 0 {name=p16 sig_type=std_logic lab=VBIAS}
C {gnd.sym} 100 310 0 0 {name=l36 lab=GND}
C {symbols/nfet_03v3.sym} -60 180 0 0 {name=M52
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 80 180 0 0 {name=M53
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 80 260 0 0 {name=M54
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {Local_encoder.sym} -290 70 0 0 {name=x9}
C {res.sym} 690 -30 0 0 {name=R19
value=500
footprint=1206
device=resistor
m=1}
C {res.sym} 870 -30 0 0 {name=R20
value=500
footprint=1206
device=resistor
m=1}
C {symbols/nfet_03v3.sym} 670 60 0 0 {name=M55
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 890 60 0 1 {name=M56
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 720 110 0 0 {name=l37 lab=GND}
C {gnd.sym} 840 110 0 0 {name=l38 lab=GND}
C {gnd.sym} 720 310 0 0 {name=l39 lab=GND}
C {symbols/nfet_03v3.sym} 700 260 0 0 {name=M57
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 660 180 0 0 {name=p17 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 660 260 0 0 {name=p18 sig_type=std_logic lab=VBIAS}
C {gnd.sym} 860 320 0 0 {name=l40 lab=GND}
C {symbols/nfet_03v3.sym} 700 180 0 0 {name=M58
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 840 180 0 0 {name=M59
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 840 260 0 0 {name=M60
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {Local_encoder.sym} 470 70 0 0 {name=x10}
C {res.sym} 1390 -30 0 0 {name=R21
value=500
footprint=1206
device=resistor
m=1}
C {res.sym} 1570 -30 0 0 {name=R22
value=500
footprint=1206
device=resistor
m=1}
C {symbols/nfet_03v3.sym} 1370 60 0 0 {name=M61
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 1590 60 0 1 {name=M62
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 1420 110 0 0 {name=l41 lab=GND}
C {gnd.sym} 1540 110 0 0 {name=l42 lab=GND}
C {gnd.sym} 1420 320 0 0 {name=l43 lab=GND}
C {symbols/nfet_03v3.sym} 1400 260 0 0 {name=M63
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 1360 180 0 0 {name=p19 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 1360 260 0 0 {name=p20 sig_type=std_logic lab=VBIAS}
C {gnd.sym} 1560 320 0 0 {name=l44 lab=GND}
C {symbols/nfet_03v3.sym} 1400 180 0 0 {name=M64
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 1540 180 0 0 {name=M65
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 1540 260 0 0 {name=M66
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {Local_encoder.sym} 1170 70 0 0 {name=x11}
C {res.sym} 2120 -30 0 0 {name=R23
value=500
footprint=1206
device=resistor
m=1}
C {res.sym} 2300 -20 0 0 {name=R24
value=500
footprint=1206
device=resistor
m=1}
C {symbols/nfet_03v3.sym} 2100 60 0 0 {name=M67
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2320 60 0 1 {name=M68
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 2150 110 0 0 {name=l45 lab=GND}
C {gnd.sym} 2270 110 0 0 {name=l46 lab=GND}
C {gnd.sym} 2150 320 0 0 {name=l47 lab=GND}
C {symbols/nfet_03v3.sym} 2130 260 0 0 {name=M69
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 2090 180 0 0 {name=p21 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 2090 260 0 0 {name=p22 sig_type=std_logic lab=VBIAS}
C {gnd.sym} 2290 320 0 0 {name=l48 lab=GND}
C {symbols/nfet_03v3.sym} 2130 180 0 0 {name=M70
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2270 180 0 0 {name=M71
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2270 260 0 0 {name=M72
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {Local_encoder.sym} 1900 70 0 0 {name=x12}
C {res.sym} 2840 -30 0 0 {name=R25
value=500
footprint=1206
device=resistor
m=1}
C {res.sym} 3020 -30 0 0 {name=R26
value=500
footprint=1206
device=resistor
m=1}
C {symbols/nfet_03v3.sym} 2820 60 0 0 {name=M73
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 3040 60 0 1 {name=M74
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 2870 110 0 0 {name=l49 lab=GND}
C {gnd.sym} 2990 110 0 0 {name=l50 lab=GND}
C {gnd.sym} 2870 320 0 0 {name=l51 lab=GND}
C {symbols/nfet_03v3.sym} 2850 260 0 0 {name=M75
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 2810 180 0 0 {name=p23 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 2810 260 0 0 {name=p24 sig_type=std_logic lab=VBIAS}
C {gnd.sym} 3010 320 0 0 {name=l52 lab=GND}
C {symbols/nfet_03v3.sym} 2850 180 0 0 {name=M76
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2990 180 0 0 {name=M77
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2990 260 0 0 {name=M78
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {Local_encoder.sym} 2620 70 0 0 {name=x13}
C {res.sym} 3550 -20 0 0 {name=R27
value=500
footprint=1206
device=resistor
m=1}
C {res.sym} 3730 -30 0 0 {name=R28
value=500
footprint=1206
device=resistor
m=1}
C {symbols/nfet_03v3.sym} 3750 60 0 1 {name=M80
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 3580 110 0 0 {name=l53 lab=GND}
C {gnd.sym} 3700 110 0 0 {name=l54 lab=GND}
C {gnd.sym} 3580 320 0 0 {name=l55 lab=GND}
C {symbols/nfet_03v3.sym} 3560 260 0 0 {name=M81
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3520 180 0 0 {name=p25 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 3520 260 0 0 {name=p26 sig_type=std_logic lab=VBIAS}
C {gnd.sym} 3720 320 0 0 {name=l56 lab=GND}
C {symbols/nfet_03v3.sym} 3560 180 0 0 {name=M82
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 3700 180 0 0 {name=M83
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 3700 260 0 0 {name=M84
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {Local_encoder.sym} 3330 70 0 0 {name=x14}
C {res.sym} 4260 -20 0 0 {name=R29
value=500
footprint=1206
device=resistor
m=1}
C {res.sym} 4440 -20 0 0 {name=R30
value=500
footprint=1206
device=resistor
m=1}
C {symbols/nfet_03v3.sym} 4240 60 0 0 {name=M85
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 4460 60 0 1 {name=M86
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 4290 110 0 0 {name=l57 lab=GND}
C {gnd.sym} 4410 110 0 0 {name=l58 lab=GND}
C {gnd.sym} 4290 320 0 0 {name=l59 lab=GND}
C {symbols/nfet_03v3.sym} 4270 260 0 0 {name=M87
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4230 180 0 0 {name=p27 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 4230 260 0 0 {name=p28 sig_type=std_logic lab=VBIAS}
C {gnd.sym} 4430 320 0 0 {name=l60 lab=GND}
C {symbols/nfet_03v3.sym} 4270 180 0 0 {name=M88
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 4410 180 0 0 {name=M89
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 4410 260 0 0 {name=M90
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {Local_encoder.sym} 4040 70 0 0 {name=x15}
C {res.sym} 4960 -10 0 0 {name=R31
value=500
footprint=1206
device=resistor
m=1}
C {res.sym} 5140 -10 0 0 {name=R32
value=500
footprint=1206
device=resistor
m=1}
C {symbols/nfet_03v3.sym} 4940 80 0 0 {name=M91
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 5160 80 0 1 {name=M92
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 4990 130 0 0 {name=l61 lab=GND}
C {gnd.sym} 5110 130 0 0 {name=l62 lab=GND}
C {gnd.sym} 4850 300 0 0 {name=l63 lab=GND}
C {symbols/nfet_03v3.sym} 4970 280 0 0 {name=M93
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4930 200 0 0 {name=p29 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 4930 280 0 0 {name=p30 sig_type=std_logic lab=VBIAS}
C {gnd.sym} 5210 320 0 0 {name=l64 lab=GND}
C {symbols/nfet_03v3.sym} 4970 200 0 0 {name=M94
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 5110 200 0 0 {name=M95
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 5110 280 0 0 {name=M96
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {Local_encoder.sym} 4740 90 0 0 {name=x16}
C {res.sym} -70 420 0 0 {name=R33
value=500
footprint=1206
device=resistor
m=1}
C {res.sym} 110 410 0 0 {name=R34
value=500
footprint=1206
device=resistor
m=1}
C {symbols/nfet_03v3.sym} -90 510 0 0 {name=M97
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 130 510 0 1 {name=M98
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} -40 560 0 0 {name=l65 lab=GND}
C {gnd.sym} 80 560 0 0 {name=l66 lab=GND}
C {gnd.sym} -40 770 0 0 {name=l67 lab=GND}
C {symbols/nfet_03v3.sym} -60 710 0 0 {name=M99
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} -100 630 0 0 {name=p31 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} -100 710 0 0 {name=p32 sig_type=std_logic lab=VBIAS}
C {gnd.sym} 100 770 0 0 {name=l68 lab=GND}
C {symbols/nfet_03v3.sym} -60 630 0 0 {name=M100
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 80 630 0 0 {name=M101
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 80 710 0 0 {name=M102
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {Local_encoder.sym} -290 520 0 0 {name=x17}
C {res.sym} 690 420 0 0 {name=R35
value=500
footprint=1206
device=resistor
m=1}
C {res.sym} 870 410 0 0 {name=R36
value=500
footprint=1206
device=resistor
m=1}
C {symbols/nfet_03v3.sym} 670 510 0 0 {name=M103
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 890 510 0 1 {name=M104
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 720 560 0 0 {name=l69 lab=GND}
C {gnd.sym} 840 560 0 0 {name=l70 lab=GND}
C {gnd.sym} 720 770 0 0 {name=l71 lab=GND}
C {symbols/nfet_03v3.sym} 700 710 0 0 {name=M105
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 660 630 0 0 {name=p33 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 660 710 0 0 {name=p34 sig_type=std_logic lab=VBIAS}
C {gnd.sym} 860 770 0 0 {name=l72 lab=GND}
C {symbols/nfet_03v3.sym} 700 630 0 0 {name=M106
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 840 630 0 0 {name=M107
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 840 710 0 0 {name=M108
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {Local_encoder.sym} 470 520 0 0 {name=x18}
C {res.sym} 1390 420 0 0 {name=R37
value=500
footprint=1206
device=resistor
m=1}
C {res.sym} 1570 410 0 0 {name=R38
value=500
footprint=1206
device=resistor
m=1}
C {symbols/nfet_03v3.sym} 1370 510 0 0 {name=M109
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 1590 510 0 1 {name=M110
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 1420 560 0 0 {name=l73 lab=GND}
C {gnd.sym} 1540 560 0 0 {name=l74 lab=GND}
C {gnd.sym} 1420 770 0 0 {name=l75 lab=GND}
C {symbols/nfet_03v3.sym} 1400 710 0 0 {name=M111
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 1360 630 0 0 {name=p35 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 1360 710 0 0 {name=p36 sig_type=std_logic lab=VBIAS}
C {gnd.sym} 1560 770 0 0 {name=l76 lab=GND}
C {symbols/nfet_03v3.sym} 1400 630 0 0 {name=M112
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 1540 630 0 0 {name=M113
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 1540 710 0 0 {name=M114
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {Local_encoder.sym} 1170 520 0 0 {name=x19}
C {res.sym} 2120 420 0 0 {name=R39
value=500
footprint=1206
device=resistor
m=1}
C {res.sym} 2300 410 0 0 {name=R40
value=500
footprint=1206
device=resistor
m=1}
C {symbols/nfet_03v3.sym} 2100 510 0 0 {name=M115
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2320 510 0 1 {name=M116
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 2150 560 0 0 {name=l77 lab=GND}
C {gnd.sym} 2270 560 0 0 {name=l78 lab=GND}
C {gnd.sym} 2150 770 0 0 {name=l79 lab=GND}
C {symbols/nfet_03v3.sym} 2130 710 0 0 {name=M117
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 2090 630 0 0 {name=p37 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 2090 710 0 0 {name=p38 sig_type=std_logic lab=VBIAS}
C {gnd.sym} 2290 770 0 0 {name=l80 lab=GND}
C {symbols/nfet_03v3.sym} 2130 630 0 0 {name=M118
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2270 630 0 0 {name=M119
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2270 710 0 0 {name=M120
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {Local_encoder.sym} 1900 520 0 0 {name=x20}
C {res.sym} 2840 420 0 0 {name=R41
value=500
footprint=1206
device=resistor
m=1}
C {res.sym} 3020 410 0 0 {name=R42
value=500
footprint=1206
device=resistor
m=1}
C {symbols/nfet_03v3.sym} 2820 510 0 0 {name=M121
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 3040 510 0 1 {name=M122
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 2870 560 0 0 {name=l81 lab=GND}
C {gnd.sym} 2990 560 0 0 {name=l82 lab=GND}
C {gnd.sym} 2870 770 0 0 {name=l83 lab=GND}
C {symbols/nfet_03v3.sym} 2850 710 0 0 {name=M123
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 2810 630 0 0 {name=p39 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 2810 710 0 0 {name=p40 sig_type=std_logic lab=VBIAS}
C {gnd.sym} 3010 770 0 0 {name=l84 lab=GND}
C {symbols/nfet_03v3.sym} 2850 630 0 0 {name=M124
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2990 630 0 0 {name=M125
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2990 710 0 0 {name=M126
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {Local_encoder.sym} 2620 520 0 0 {name=x21}
C {res.sym} 3550 420 0 0 {name=R43
value=500
footprint=1206
device=resistor
m=1}
C {res.sym} 3730 410 0 0 {name=R44
value=500
footprint=1206
device=resistor
m=1}
C {symbols/nfet_03v3.sym} 3530 510 0 0 {name=M127
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 3750 510 0 1 {name=M128
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 3580 560 0 0 {name=l85 lab=GND}
C {gnd.sym} 3700 560 0 0 {name=l86 lab=GND}
C {gnd.sym} 3580 770 0 0 {name=l87 lab=GND}
C {symbols/nfet_03v3.sym} 3560 710 0 0 {name=M129
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3520 630 0 0 {name=p41 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 3520 710 0 0 {name=p44 sig_type=std_logic lab=VBIAS}
C {gnd.sym} 3720 770 0 0 {name=l88 lab=GND}
C {symbols/nfet_03v3.sym} 3560 630 0 0 {name=M130
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 3700 630 0 0 {name=M131
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 3700 710 0 0 {name=M132
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {Local_encoder.sym} 3330 520 0 0 {name=x22}
C {res.sym} 4260 420 0 0 {name=R45
value=500
footprint=1206
device=resistor
m=1}
C {res.sym} 4440 410 0 0 {name=R46
value=500
footprint=1206
device=resistor
m=1}
C {symbols/nfet_03v3.sym} 4240 510 0 0 {name=M133
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 4460 510 0 1 {name=M134
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 4290 560 0 0 {name=l89 lab=GND}
C {gnd.sym} 4410 560 0 0 {name=l90 lab=GND}
C {gnd.sym} 4290 770 0 0 {name=l91 lab=GND}
C {symbols/nfet_03v3.sym} 4270 710 0 0 {name=M135
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4230 630 0 0 {name=p45 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 4230 710 0 0 {name=p46 sig_type=std_logic lab=VBIAS}
C {gnd.sym} 4430 770 0 0 {name=l92 lab=GND}
C {symbols/nfet_03v3.sym} 4270 630 0 0 {name=M136
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 4410 630 0 0 {name=M137
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 4410 710 0 0 {name=M138
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {Local_encoder.sym} 4040 520 0 0 {name=x23}
C {res.sym} 4960 420 0 0 {name=R47
value=500
footprint=1206
device=resistor
m=1}
C {res.sym} 5140 410 0 0 {name=R48
value=500
footprint=1206
device=resistor
m=1}
C {symbols/nfet_03v3.sym} 4940 510 0 0 {name=M139
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 5160 510 0 1 {name=M140
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 4990 560 0 0 {name=l93 lab=GND}
C {gnd.sym} 5110 560 0 0 {name=l94 lab=GND}
C {gnd.sym} 4990 770 0 0 {name=l95 lab=GND}
C {symbols/nfet_03v3.sym} 4970 710 0 0 {name=M141
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4930 630 0 0 {name=p47 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 4930 710 0 0 {name=p48 sig_type=std_logic lab=VBIAS}
C {gnd.sym} 5130 770 0 0 {name=l96 lab=GND}
C {symbols/nfet_03v3.sym} 4970 630 0 0 {name=M142
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 5110 630 0 0 {name=M143
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 5110 710 0 0 {name=M144
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {Local_encoder.sym} 4740 520 0 0 {name=x24}
C {res.sym} -70 930 0 0 {name=R49
value=500
footprint=1206
device=resistor
m=1}
C {res.sym} 110 920 0 0 {name=R50
value=500
footprint=1206
device=resistor
m=1}
C {symbols/nfet_03v3.sym} -90 1020 0 0 {name=M145
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 130 1020 0 1 {name=M146
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} -40 1070 0 0 {name=l97 lab=GND}
C {gnd.sym} 80 1070 0 0 {name=l98 lab=GND}
C {gnd.sym} -40 1280 0 0 {name=l99 lab=GND}
C {symbols/nfet_03v3.sym} -60 1220 0 0 {name=M147
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} -100 1140 0 0 {name=p49 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} -100 1220 0 0 {name=p50 sig_type=std_logic lab=VBIAS}
C {gnd.sym} 100 1280 0 0 {name=l100 lab=GND}
C {symbols/nfet_03v3.sym} -60 1140 0 0 {name=M148
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 80 1140 0 0 {name=M149
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 80 1220 0 0 {name=M150
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {Local_encoder.sym} -290 1030 0 0 {name=x25}
C {res.sym} 690 930 0 0 {name=R51
value=500
footprint=1206
device=resistor
m=1}
C {res.sym} 870 920 0 0 {name=R52
value=500
footprint=1206
device=resistor
m=1}
C {symbols/nfet_03v3.sym} 670 1020 0 0 {name=M151
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 890 1020 0 1 {name=M152
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 720 1070 0 0 {name=l101 lab=GND}
C {gnd.sym} 840 1070 0 0 {name=l102 lab=GND}
C {gnd.sym} 720 1280 0 0 {name=l103 lab=GND}
C {symbols/nfet_03v3.sym} 700 1220 0 0 {name=M153
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 660 1140 0 0 {name=p51 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 660 1220 0 0 {name=p52 sig_type=std_logic lab=VBIAS}
C {gnd.sym} 860 1280 0 0 {name=l104 lab=GND}
C {symbols/nfet_03v3.sym} 700 1140 0 0 {name=M154
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 840 1140 0 0 {name=M155
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 840 1220 0 0 {name=M156
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {Local_encoder.sym} 470 1030 0 0 {name=x26}
C {res.sym} 1390 930 0 0 {name=R53
value=500
footprint=1206
device=resistor
m=1}
C {res.sym} 1570 920 0 0 {name=R54
value=500
footprint=1206
device=resistor
m=1}
C {symbols/nfet_03v3.sym} 1370 1020 0 0 {name=M157
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 1590 1020 0 1 {name=M158
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 1420 1070 0 0 {name=l105 lab=GND}
C {gnd.sym} 1540 1070 0 0 {name=l106 lab=GND}
C {gnd.sym} 1420 1280 0 0 {name=l107 lab=GND}
C {symbols/nfet_03v3.sym} 1400 1220 0 0 {name=M159
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 1360 1140 0 0 {name=p53 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 1360 1220 0 0 {name=p54 sig_type=std_logic lab=VBIAS}
C {gnd.sym} 1560 1280 0 0 {name=l108 lab=GND}
C {symbols/nfet_03v3.sym} 1400 1140 0 0 {name=M160
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 1540 1140 0 0 {name=M161
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 1540 1220 0 0 {name=M162
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {Local_encoder.sym} 1170 1030 0 0 {name=x27}
C {res.sym} 2120 930 0 0 {name=R55
value=500
footprint=1206
device=resistor
m=1}
C {res.sym} 2300 920 0 0 {name=R56
value=500
footprint=1206
device=resistor
m=1}
C {symbols/nfet_03v3.sym} 2100 1020 0 0 {name=M163
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2320 1020 0 1 {name=M164
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 2150 1070 0 0 {name=l109 lab=GND}
C {gnd.sym} 2270 1070 0 0 {name=l110 lab=GND}
C {gnd.sym} 2150 1280 0 0 {name=l111 lab=GND}
C {symbols/nfet_03v3.sym} 2130 1220 0 0 {name=M165
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 2090 1140 0 0 {name=p55 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 2090 1220 0 0 {name=p56 sig_type=std_logic lab=VBIAS}
C {gnd.sym} 2290 1280 0 0 {name=l112 lab=GND}
C {symbols/nfet_03v3.sym} 2130 1140 0 0 {name=M166
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2270 1140 0 0 {name=M167
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2270 1220 0 0 {name=M168
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {Local_encoder.sym} 1900 1030 0 0 {name=x28}
C {res.sym} 2840 930 0 0 {name=R57
value=500
footprint=1206
device=resistor
m=1}
C {res.sym} 3020 920 0 0 {name=R58
value=500
footprint=1206
device=resistor
m=1}
C {symbols/nfet_03v3.sym} 2820 1020 0 0 {name=M169
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 3040 1020 0 1 {name=M170
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 2870 1070 0 0 {name=l113 lab=GND}
C {gnd.sym} 2990 1070 0 0 {name=l114 lab=GND}
C {gnd.sym} 2870 1280 0 0 {name=l115 lab=GND}
C {symbols/nfet_03v3.sym} 2850 1220 0 0 {name=M171
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 2810 1140 0 0 {name=p57 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 2810 1220 0 0 {name=p58 sig_type=std_logic lab=VBIAS}
C {gnd.sym} 3010 1280 0 0 {name=l116 lab=GND}
C {symbols/nfet_03v3.sym} 2850 1140 0 0 {name=M172
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2990 1140 0 0 {name=M173
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2990 1220 0 0 {name=M174
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {Local_encoder.sym} 2620 1030 0 0 {name=x29}
C {res.sym} 3550 930 0 0 {name=R59
value=500
footprint=1206
device=resistor
m=1}
C {res.sym} 3730 920 0 0 {name=R60
value=500
footprint=1206
device=resistor
m=1}
C {symbols/nfet_03v3.sym} 3530 1020 0 0 {name=M175
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 3750 1020 0 1 {name=M176
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 3580 1070 0 0 {name=l117 lab=GND}
C {gnd.sym} 3700 1070 0 0 {name=l118 lab=GND}
C {gnd.sym} 3580 1280 0 0 {name=l119 lab=GND}
C {symbols/nfet_03v3.sym} 3560 1220 0 0 {name=M177
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3520 1140 0 0 {name=p59 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 3520 1220 0 0 {name=p60 sig_type=std_logic lab=VBIAS}
C {gnd.sym} 3720 1280 0 0 {name=l120 lab=GND}
C {symbols/nfet_03v3.sym} 3560 1140 0 0 {name=M178
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 3700 1140 0 0 {name=M179
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 3700 1220 0 0 {name=M180
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {Local_encoder.sym} 3330 1030 0 0 {name=x30}
C {res.sym} 4260 930 0 0 {name=R61
value=500
footprint=1206
device=resistor
m=1}
C {res.sym} 4440 920 0 0 {name=R62
value=500
footprint=1206
device=resistor
m=1}
C {symbols/nfet_03v3.sym} 4240 1020 0 0 {name=M181
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 4460 1020 0 1 {name=M182
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 4290 1070 0 0 {name=l121 lab=GND}
C {gnd.sym} 4410 1070 0 0 {name=l122 lab=GND}
C {gnd.sym} 4290 1280 0 0 {name=l123 lab=GND}
C {symbols/nfet_03v3.sym} 4270 1220 0 0 {name=M183
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4230 1140 0 0 {name=p61 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 4230 1220 0 0 {name=p62 sig_type=std_logic lab=VBIAS}
C {gnd.sym} 4430 1280 0 0 {name=l124 lab=GND}
C {symbols/nfet_03v3.sym} 4270 1140 0 0 {name=M184
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 4410 1140 0 0 {name=M185
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 4410 1220 0 0 {name=M186
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {Local_encoder.sym} 4040 1030 0 0 {name=x31}
C {res.sym} 4960 930 0 0 {name=R63
value=500
footprint=1206
device=resistor
m=1}
C {res.sym} 5140 920 0 0 {name=R64
value=500
footprint=1206
device=resistor
m=1}
C {symbols/nfet_03v3.sym} 4940 1020 0 0 {name=M187
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 5160 1020 0 1 {name=M188
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 4990 1070 0 0 {name=l125 lab=GND}
C {gnd.sym} 5110 1070 0 0 {name=l126 lab=GND}
C {gnd.sym} 4990 1280 0 0 {name=l127 lab=GND}
C {symbols/nfet_03v3.sym} 4970 1220 0 0 {name=M189
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4930 1140 0 0 {name=p63 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 4930 1220 0 0 {name=p64 sig_type=std_logic lab=VBIAS}
C {gnd.sym} 5130 1280 0 0 {name=l128 lab=GND}
C {symbols/nfet_03v3.sym} 4970 1140 0 0 {name=M190
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 5110 1140 0 0 {name=M191
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 5110 1220 0 0 {name=M192
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {Local_encoder.sym} 4740 1030 0 0 {name=x32}
C {res.sym} -70 1400 0 0 {name=R65
value=500
footprint=1206
device=resistor
m=1}
C {res.sym} 110 1390 0 0 {name=R66
value=500
footprint=1206
device=resistor
m=1}
C {symbols/nfet_03v3.sym} -90 1490 0 0 {name=M193
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 130 1490 0 1 {name=M194
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} -40 1540 0 0 {name=l129 lab=GND}
C {gnd.sym} 80 1540 0 0 {name=l130 lab=GND}
C {gnd.sym} -40 1750 0 0 {name=l131 lab=GND}
C {symbols/nfet_03v3.sym} -60 1690 0 0 {name=M195
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} -100 1610 0 0 {name=p65 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} -100 1690 0 0 {name=p66 sig_type=std_logic lab=VBIAS}
C {gnd.sym} 100 1750 0 0 {name=l132 lab=GND}
C {symbols/nfet_03v3.sym} -60 1610 0 0 {name=M196
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 80 1610 0 0 {name=M197
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 80 1690 0 0 {name=M198
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {Local_encoder.sym} -290 1500 0 0 {name=x33}
C {res.sym} 690 1400 0 0 {name=R67
value=500
footprint=1206
device=resistor
m=1}
C {res.sym} 870 1390 0 0 {name=R68
value=500
footprint=1206
device=resistor
m=1}
C {symbols/nfet_03v3.sym} 670 1490 0 0 {name=M199
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 890 1490 0 1 {name=M200
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 720 1540 0 0 {name=l133 lab=GND}
C {gnd.sym} 840 1540 0 0 {name=l134 lab=GND}
C {gnd.sym} 720 1750 0 0 {name=l135 lab=GND}
C {symbols/nfet_03v3.sym} 700 1690 0 0 {name=M201
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 660 1610 0 0 {name=p67 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 660 1690 0 0 {name=p68 sig_type=std_logic lab=VBIAS}
C {gnd.sym} 860 1750 0 0 {name=l136 lab=GND}
C {symbols/nfet_03v3.sym} 700 1610 0 0 {name=M202
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 840 1610 0 0 {name=M203
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 840 1690 0 0 {name=M204
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {Local_encoder.sym} 470 1500 0 0 {name=x34}
C {res.sym} 1390 1400 0 0 {name=R69
value=500
footprint=1206
device=resistor
m=1}
C {res.sym} 1570 1390 0 0 {name=R70
value=500
footprint=1206
device=resistor
m=1}
C {symbols/nfet_03v3.sym} 1370 1490 0 0 {name=M205
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 1590 1490 0 1 {name=M206
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 1420 1540 0 0 {name=l137 lab=GND}
C {gnd.sym} 1540 1540 0 0 {name=l138 lab=GND}
C {gnd.sym} 1420 1750 0 0 {name=l139 lab=GND}
C {symbols/nfet_03v3.sym} 1400 1690 0 0 {name=M207
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 1360 1610 0 0 {name=p69 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 1360 1690 0 0 {name=p70 sig_type=std_logic lab=VBIAS}
C {gnd.sym} 1560 1750 0 0 {name=l140 lab=GND}
C {symbols/nfet_03v3.sym} 1400 1610 0 0 {name=M208
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 1540 1610 0 0 {name=M209
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 1540 1690 0 0 {name=M210
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {Local_encoder.sym} 1170 1500 0 0 {name=x35}
C {res.sym} 2120 1400 0 0 {name=R71
value=500
footprint=1206
device=resistor
m=1}
C {res.sym} 2300 1390 0 0 {name=R72
value=500
footprint=1206
device=resistor
m=1}
C {symbols/nfet_03v3.sym} 2100 1490 0 0 {name=M211
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2320 1490 0 1 {name=M212
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 2150 1540 0 0 {name=l141 lab=GND}
C {gnd.sym} 2270 1540 0 0 {name=l142 lab=GND}
C {gnd.sym} 2150 1750 0 0 {name=l143 lab=GND}
C {symbols/nfet_03v3.sym} 2130 1690 0 0 {name=M213
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 2090 1610 0 0 {name=p71 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 2090 1690 0 0 {name=p72 sig_type=std_logic lab=VBIAS}
C {gnd.sym} 2290 1750 0 0 {name=l144 lab=GND}
C {symbols/nfet_03v3.sym} 2130 1610 0 0 {name=M214
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2270 1610 0 0 {name=M215
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2270 1690 0 0 {name=M216
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {Local_encoder.sym} 1900 1500 0 0 {name=x36}
C {res.sym} 2840 1400 0 0 {name=R73
value=500
footprint=1206
device=resistor
m=1}
C {res.sym} 3020 1390 0 0 {name=R74
value=500
footprint=1206
device=resistor
m=1}
C {symbols/nfet_03v3.sym} 2820 1490 0 0 {name=M217
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 3040 1490 0 1 {name=M218
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 2870 1540 0 0 {name=l145 lab=GND}
C {gnd.sym} 2990 1540 0 0 {name=l146 lab=GND}
C {gnd.sym} 2870 1750 0 0 {name=l147 lab=GND}
C {symbols/nfet_03v3.sym} 2850 1690 0 0 {name=M219
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 2810 1610 0 0 {name=p73 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 2810 1690 0 0 {name=p74 sig_type=std_logic lab=VBIAS}
C {gnd.sym} 3010 1750 0 0 {name=l148 lab=GND}
C {symbols/nfet_03v3.sym} 2850 1610 0 0 {name=M220
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2990 1610 0 0 {name=M221
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2990 1690 0 0 {name=M222
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {Local_encoder.sym} 2620 1500 0 0 {name=x37}
C {res.sym} 3550 1400 0 0 {name=R75
value=500
footprint=1206
device=resistor
m=1}
C {res.sym} 3730 1390 0 0 {name=R76
value=500
footprint=1206
device=resistor
m=1}
C {symbols/nfet_03v3.sym} 3530 1490 0 0 {name=M223
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 3750 1490 0 1 {name=M224
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 3580 1540 0 0 {name=l149 lab=GND}
C {gnd.sym} 3700 1540 0 0 {name=l150 lab=GND}
C {gnd.sym} 3580 1750 0 0 {name=l151 lab=GND}
C {symbols/nfet_03v3.sym} 3560 1690 0 0 {name=M225
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3520 1610 0 0 {name=p75 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 3520 1690 0 0 {name=p76 sig_type=std_logic lab=VBIAS}
C {gnd.sym} 3720 1750 0 0 {name=l152 lab=GND}
C {symbols/nfet_03v3.sym} 3560 1610 0 0 {name=M226
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 3700 1610 0 0 {name=M227
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 3700 1690 0 0 {name=M228
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {Local_encoder.sym} 3330 1500 0 0 {name=x38}
C {res.sym} 4260 1400 0 0 {name=R77
value=500
footprint=1206
device=resistor
m=1}
C {res.sym} 4440 1390 0 0 {name=R78
value=500
footprint=1206
device=resistor
m=1}
C {symbols/nfet_03v3.sym} 4240 1490 0 0 {name=M229
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 4460 1490 0 1 {name=M230
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 4290 1540 0 0 {name=l153 lab=GND}
C {gnd.sym} 4410 1540 0 0 {name=l154 lab=GND}
C {gnd.sym} 4290 1750 0 0 {name=l155 lab=GND}
C {symbols/nfet_03v3.sym} 4270 1690 0 0 {name=M231
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4230 1610 0 0 {name=p77 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 4230 1690 0 0 {name=p78 sig_type=std_logic lab=VBIAS}
C {gnd.sym} 4430 1750 0 0 {name=l156 lab=GND}
C {symbols/nfet_03v3.sym} 4270 1610 0 0 {name=M232
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 4410 1610 0 0 {name=M233
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 4410 1690 0 0 {name=M234
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {Local_encoder.sym} 4040 1500 0 0 {name=x39}
C {res.sym} 4960 1400 0 0 {name=R79
value=500
footprint=1206
device=resistor
m=1}
C {res.sym} 5140 1390 0 0 {name=R80
value=500
footprint=1206
device=resistor
m=1}
C {symbols/nfet_03v3.sym} 4940 1490 0 0 {name=M235
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 5160 1490 0 1 {name=M236
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 4990 1540 0 0 {name=l157 lab=GND}
C {gnd.sym} 5110 1540 0 0 {name=l158 lab=GND}
C {gnd.sym} 4990 1750 0 0 {name=l159 lab=GND}
C {symbols/nfet_03v3.sym} 4970 1690 0 0 {name=M237
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4930 1610 0 0 {name=p79 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 4930 1690 0 0 {name=p80 sig_type=std_logic lab=VBIAS}
C {gnd.sym} 5130 1750 0 0 {name=l160 lab=GND}
C {symbols/nfet_03v3.sym} 4970 1610 0 0 {name=M238
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 5110 1610 0 0 {name=M239
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 5110 1690 0 0 {name=M240
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {Local_encoder.sym} 4740 1500 0 0 {name=x40}
C {res.sym} -70 1900 0 0 {name=R81
value=500
footprint=1206
device=resistor
m=1}
C {res.sym} 110 1890 0 0 {name=R82
value=500
footprint=1206
device=resistor
m=1}
C {symbols/nfet_03v3.sym} -90 1990 0 0 {name=M241
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 130 1990 0 1 {name=M242
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} -40 2040 0 0 {name=l161 lab=GND}
C {gnd.sym} 80 2040 0 0 {name=l162 lab=GND}
C {gnd.sym} -40 2250 0 0 {name=l163 lab=GND}
C {symbols/nfet_03v3.sym} -60 2190 0 0 {name=M243
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} -100 2110 0 0 {name=p81 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} -100 2190 0 0 {name=p82 sig_type=std_logic lab=VBIAS}
C {gnd.sym} 100 2250 0 0 {name=l164 lab=GND}
C {symbols/nfet_03v3.sym} -60 2110 0 0 {name=M244
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 80 2110 0 0 {name=M245
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 80 2190 0 0 {name=M246
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {Local_encoder.sym} -290 2000 0 0 {name=x41}
C {res.sym} 690 1900 0 0 {name=R83
value=500
footprint=1206
device=resistor
m=1}
C {res.sym} 870 1890 0 0 {name=R84
value=500
footprint=1206
device=resistor
m=1}
C {symbols/nfet_03v3.sym} 670 1990 0 0 {name=M247
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 890 1990 0 1 {name=M248
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 720 2040 0 0 {name=l165 lab=GND}
C {gnd.sym} 840 2040 0 0 {name=l166 lab=GND}
C {gnd.sym} 720 2250 0 0 {name=l167 lab=GND}
C {symbols/nfet_03v3.sym} 700 2190 0 0 {name=M249
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 660 2110 0 0 {name=p83 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 660 2190 0 0 {name=p84 sig_type=std_logic lab=VBIAS}
C {gnd.sym} 860 2250 0 0 {name=l168 lab=GND}
C {symbols/nfet_03v3.sym} 700 2110 0 0 {name=M250
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 840 2110 0 0 {name=M251
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 840 2190 0 0 {name=M252
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {Local_encoder.sym} 470 2000 0 0 {name=x42}
C {res.sym} 1390 1900 0 0 {name=R85
value=500
footprint=1206
device=resistor
m=1}
C {res.sym} 1570 1890 0 0 {name=R86
value=500
footprint=1206
device=resistor
m=1}
C {symbols/nfet_03v3.sym} 1370 1990 0 0 {name=M253
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 1590 1990 0 1 {name=M254
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 1420 2040 0 0 {name=l169 lab=GND}
C {gnd.sym} 1540 2040 0 0 {name=l170 lab=GND}
C {gnd.sym} 1420 2250 0 0 {name=l171 lab=GND}
C {symbols/nfet_03v3.sym} 1400 2190 0 0 {name=M255
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 1360 2110 0 0 {name=p85 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 1360 2190 0 0 {name=p86 sig_type=std_logic lab=VBIAS}
C {gnd.sym} 1560 2250 0 0 {name=l172 lab=GND}
C {symbols/nfet_03v3.sym} 1400 2110 0 0 {name=M256
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 1540 2110 0 0 {name=M257
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 1540 2190 0 0 {name=M258
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {Local_encoder.sym} 1170 2000 0 0 {name=x43}
C {res.sym} 2120 1900 0 0 {name=R87
value=500
footprint=1206
device=resistor
m=1}
C {res.sym} 2300 1890 0 0 {name=R88
value=500
footprint=1206
device=resistor
m=1}
C {symbols/nfet_03v3.sym} 2100 1990 0 0 {name=M259
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2320 1990 0 1 {name=M260
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 2150 2040 0 0 {name=l173 lab=GND}
C {gnd.sym} 2270 2040 0 0 {name=l174 lab=GND}
C {gnd.sym} 2150 2250 0 0 {name=l175 lab=GND}
C {symbols/nfet_03v3.sym} 2130 2190 0 0 {name=M261
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 2090 2110 0 0 {name=p87 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 2090 2190 0 0 {name=p88 sig_type=std_logic lab=VBIAS}
C {gnd.sym} 2290 2250 0 0 {name=l176 lab=GND}
C {symbols/nfet_03v3.sym} 2130 2110 0 0 {name=M262
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2270 2110 0 0 {name=M263
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2270 2190 0 0 {name=M264
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {Local_encoder.sym} 1900 2000 0 0 {name=x44}
C {res.sym} 2840 1900 0 0 {name=R89
value=500
footprint=1206
device=resistor
m=1}
C {res.sym} 3020 1890 0 0 {name=R90
value=500
footprint=1206
device=resistor
m=1}
C {symbols/nfet_03v3.sym} 2820 1990 0 0 {name=M265
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 3040 1990 0 1 {name=M266
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 2870 2040 0 0 {name=l177 lab=GND}
C {gnd.sym} 2990 2040 0 0 {name=l178 lab=GND}
C {gnd.sym} 2870 2250 0 0 {name=l179 lab=GND}
C {symbols/nfet_03v3.sym} 2850 2190 0 0 {name=M267
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 2810 2110 0 0 {name=p89 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 2810 2190 0 0 {name=p90 sig_type=std_logic lab=VBIAS}
C {gnd.sym} 3010 2250 0 0 {name=l180 lab=GND}
C {symbols/nfet_03v3.sym} 2850 2110 0 0 {name=M268
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2990 2110 0 0 {name=M269
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2990 2190 0 0 {name=M270
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {Local_encoder.sym} 2620 2000 0 0 {name=x45}
C {res.sym} 3550 1900 0 0 {name=R91
value=500
footprint=1206
device=resistor
m=1}
C {res.sym} 3730 1890 0 0 {name=R92
value=500
footprint=1206
device=resistor
m=1}
C {symbols/nfet_03v3.sym} 3530 1990 0 0 {name=M271
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 3750 1990 0 1 {name=M272
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 3580 2040 0 0 {name=l181 lab=GND}
C {gnd.sym} 3700 2040 0 0 {name=l182 lab=GND}
C {gnd.sym} 3580 2250 0 0 {name=l183 lab=GND}
C {symbols/nfet_03v3.sym} 3560 2190 0 0 {name=M273
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3520 2110 0 0 {name=p91 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 3520 2190 0 0 {name=p92 sig_type=std_logic lab=VBIAS}
C {gnd.sym} 3720 2250 0 0 {name=l184 lab=GND}
C {symbols/nfet_03v3.sym} 3560 2110 0 0 {name=M274
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 3700 2110 0 0 {name=M275
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 3700 2190 0 0 {name=M276
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {Local_encoder.sym} 3330 2000 0 0 {name=x46}
C {res.sym} 4260 1900 0 0 {name=R93
value=500
footprint=1206
device=resistor
m=1}
C {res.sym} 4440 1890 0 0 {name=R94
value=500
footprint=1206
device=resistor
m=1}
C {symbols/nfet_03v3.sym} 4240 1990 0 0 {name=M277
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 4460 1990 0 1 {name=M278
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 4290 2040 0 0 {name=l185 lab=GND}
C {gnd.sym} 4410 2040 0 0 {name=l186 lab=GND}
C {gnd.sym} 4290 2250 0 0 {name=l187 lab=GND}
C {symbols/nfet_03v3.sym} 4270 2190 0 0 {name=M279
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4230 2110 0 0 {name=p93 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 4230 2190 0 0 {name=p94 sig_type=std_logic lab=VBIAS}
C {gnd.sym} 4430 2250 0 0 {name=l188 lab=GND}
C {symbols/nfet_03v3.sym} 4270 2110 0 0 {name=M280
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 4410 2110 0 0 {name=M281
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 4410 2190 0 0 {name=M282
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {Local_encoder.sym} 4040 2000 0 0 {name=x47}
C {res.sym} 4960 1900 0 0 {name=R95
value=500
footprint=1206
device=resistor
m=1}
C {res.sym} 5140 1890 0 0 {name=R96
value=500
footprint=1206
device=resistor
m=1}
C {symbols/nfet_03v3.sym} 4940 1990 0 0 {name=M283
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 5160 1990 0 1 {name=M284
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 4990 2040 0 0 {name=l189 lab=GND}
C {gnd.sym} 5110 2040 0 0 {name=l190 lab=GND}
C {gnd.sym} 4990 2250 0 0 {name=l191 lab=GND}
C {symbols/nfet_03v3.sym} 4970 2190 0 0 {name=M285
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4930 2110 0 0 {name=p95 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 4930 2190 0 0 {name=p96 sig_type=std_logic lab=VBIAS}
C {gnd.sym} 5130 2250 0 0 {name=l192 lab=GND}
C {symbols/nfet_03v3.sym} 4970 2110 0 0 {name=M286
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 5110 2110 0 0 {name=M287
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 5110 2190 0 0 {name=M288
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {Local_encoder.sym} 4740 2000 0 0 {name=x48}
C {res.sym} -70 2360 0 0 {name=R97
value=500
footprint=1206
device=resistor
m=1}
C {res.sym} 110 2350 0 0 {name=R98
value=500
footprint=1206
device=resistor
m=1}
C {symbols/nfet_03v3.sym} -90 2450 0 0 {name=M289
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 130 2450 0 1 {name=M290
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} -40 2500 0 0 {name=l193 lab=GND}
C {gnd.sym} 80 2500 0 0 {name=l194 lab=GND}
C {gnd.sym} -40 2710 0 0 {name=l195 lab=GND}
C {symbols/nfet_03v3.sym} -60 2650 0 0 {name=M291
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} -100 2570 0 0 {name=p97 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} -100 2650 0 0 {name=p98 sig_type=std_logic lab=VBIAS}
C {gnd.sym} 100 2710 0 0 {name=l196 lab=GND}
C {symbols/nfet_03v3.sym} -60 2570 0 0 {name=M292
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 80 2570 0 0 {name=M293
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 80 2650 0 0 {name=M294
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {Local_encoder.sym} -290 2460 0 0 {name=x49}
C {res.sym} 690 2360 0 0 {name=R99
value=500
footprint=1206
device=resistor
m=1}
C {res.sym} 870 2350 0 0 {name=R100
value=500
footprint=1206
device=resistor
m=1}
C {symbols/nfet_03v3.sym} 670 2450 0 0 {name=M295
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 890 2450 0 1 {name=M296
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 720 2500 0 0 {name=l197 lab=GND}
C {gnd.sym} 840 2500 0 0 {name=l198 lab=GND}
C {gnd.sym} 720 2710 0 0 {name=l199 lab=GND}
C {symbols/nfet_03v3.sym} 700 2650 0 0 {name=M297
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 660 2570 0 0 {name=p99 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 660 2650 0 0 {name=p100 sig_type=std_logic lab=VBIAS}
C {gnd.sym} 860 2710 0 0 {name=l200 lab=GND}
C {symbols/nfet_03v3.sym} 700 2570 0 0 {name=M298
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 840 2570 0 0 {name=M299
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 840 2650 0 0 {name=M300
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {Local_encoder.sym} 470 2460 0 0 {name=x50}
C {res.sym} 1390 2360 0 0 {name=R101
value=500
footprint=1206
device=resistor
m=1}
C {res.sym} 1570 2350 0 0 {name=R102
value=500
footprint=1206
device=resistor
m=1}
C {symbols/nfet_03v3.sym} 1370 2450 0 0 {name=M301
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 1590 2450 0 1 {name=M302
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 1420 2500 0 0 {name=l201 lab=GND}
C {gnd.sym} 1540 2500 0 0 {name=l202 lab=GND}
C {gnd.sym} 1420 2710 0 0 {name=l203 lab=GND}
C {symbols/nfet_03v3.sym} 1400 2650 0 0 {name=M303
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 1360 2570 0 0 {name=p101 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 1360 2650 0 0 {name=p102 sig_type=std_logic lab=VBIAS}
C {gnd.sym} 1560 2710 0 0 {name=l204 lab=GND}
C {symbols/nfet_03v3.sym} 1400 2570 0 0 {name=M304
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 1540 2570 0 0 {name=M305
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 1540 2650 0 0 {name=M306
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {Local_encoder.sym} 1170 2460 0 0 {name=x51}
C {res.sym} 2120 2360 0 0 {name=R103
value=500
footprint=1206
device=resistor
m=1}
C {res.sym} 2300 2350 0 0 {name=R104
value=500
footprint=1206
device=resistor
m=1}
C {symbols/nfet_03v3.sym} 2100 2450 0 0 {name=M307
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2320 2450 0 1 {name=M308
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 2150 2500 0 0 {name=l205 lab=GND}
C {gnd.sym} 2270 2500 0 0 {name=l206 lab=GND}
C {gnd.sym} 2150 2710 0 0 {name=l207 lab=GND}
C {symbols/nfet_03v3.sym} 2130 2650 0 0 {name=M309
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 2090 2570 0 0 {name=p103 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 2090 2650 0 0 {name=p104 sig_type=std_logic lab=VBIAS}
C {gnd.sym} 2290 2710 0 0 {name=l208 lab=GND}
C {symbols/nfet_03v3.sym} 2130 2570 0 0 {name=M310
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2270 2570 0 0 {name=M311
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2270 2650 0 0 {name=M312
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {Local_encoder.sym} 1900 2460 0 0 {name=x52}
C {res.sym} 2840 2360 0 0 {name=R105
value=500
footprint=1206
device=resistor
m=1}
C {res.sym} 3020 2350 0 0 {name=R106
value=500
footprint=1206
device=resistor
m=1}
C {symbols/nfet_03v3.sym} 2820 2450 0 0 {name=M313
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 3040 2450 0 1 {name=M314
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 2870 2500 0 0 {name=l209 lab=GND}
C {gnd.sym} 2990 2500 0 0 {name=l210 lab=GND}
C {gnd.sym} 2870 2710 0 0 {name=l211 lab=GND}
C {symbols/nfet_03v3.sym} 2850 2650 0 0 {name=M315
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 2810 2570 0 0 {name=p105 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 2810 2650 0 0 {name=p106 sig_type=std_logic lab=VBIAS}
C {gnd.sym} 3010 2710 0 0 {name=l212 lab=GND}
C {symbols/nfet_03v3.sym} 2850 2570 0 0 {name=M316
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2990 2570 0 0 {name=M317
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2990 2650 0 0 {name=M318
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {Local_encoder.sym} 2620 2460 0 0 {name=x53}
C {res.sym} 3550 2360 0 0 {name=R107
value=500
footprint=1206
device=resistor
m=1}
C {res.sym} 3730 2350 0 0 {name=R108
value=500
footprint=1206
device=resistor
m=1}
C {symbols/nfet_03v3.sym} 3530 2450 0 0 {name=M319
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 3750 2450 0 1 {name=M320
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 3580 2500 0 0 {name=l213 lab=GND}
C {gnd.sym} 3700 2500 0 0 {name=l214 lab=GND}
C {gnd.sym} 3580 2710 0 0 {name=l215 lab=GND}
C {symbols/nfet_03v3.sym} 3560 2650 0 0 {name=M321
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3520 2570 0 0 {name=p107 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 3520 2650 0 0 {name=p108 sig_type=std_logic lab=VBIAS}
C {gnd.sym} 3720 2710 0 0 {name=l216 lab=GND}
C {symbols/nfet_03v3.sym} 3560 2570 0 0 {name=M322
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 3700 2570 0 0 {name=M323
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 3700 2650 0 0 {name=M324
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {Local_encoder.sym} 3330 2460 0 0 {name=x54}
C {res.sym} 4260 2360 0 0 {name=R109
value=500
footprint=1206
device=resistor
m=1}
C {res.sym} 4440 2350 0 0 {name=R110
value=500
footprint=1206
device=resistor
m=1}
C {symbols/nfet_03v3.sym} 4240 2450 0 0 {name=M325
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 4460 2450 0 1 {name=M326
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 4290 2500 0 0 {name=l217 lab=GND}
C {gnd.sym} 4410 2500 0 0 {name=l218 lab=GND}
C {gnd.sym} 4290 2710 0 0 {name=l219 lab=GND}
C {symbols/nfet_03v3.sym} 4270 2650 0 0 {name=M327
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4230 2570 0 0 {name=p109 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 4230 2650 0 0 {name=p110 sig_type=std_logic lab=VBIAS}
C {gnd.sym} 4430 2710 0 0 {name=l220 lab=GND}
C {symbols/nfet_03v3.sym} 4270 2570 0 0 {name=M328
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 4410 2570 0 0 {name=M329
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 4410 2650 0 0 {name=M330
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {Local_encoder.sym} 4040 2460 0 0 {name=x55}
C {res.sym} 4960 2360 0 0 {name=R111
value=500
footprint=1206
device=resistor
m=1}
C {res.sym} 5140 2350 0 0 {name=R112
value=500
footprint=1206
device=resistor
m=1}
C {symbols/nfet_03v3.sym} 4940 2450 0 0 {name=M331
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 5160 2450 0 1 {name=M332
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 4990 2500 0 0 {name=l221 lab=GND}
C {gnd.sym} 5110 2500 0 0 {name=l222 lab=GND}
C {gnd.sym} 4990 2710 0 0 {name=l223 lab=GND}
C {symbols/nfet_03v3.sym} 4970 2650 0 0 {name=M333
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4930 2570 0 0 {name=p111 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 4930 2650 0 0 {name=p112 sig_type=std_logic lab=VBIAS}
C {gnd.sym} 5130 2710 0 0 {name=l224 lab=GND}
C {symbols/nfet_03v3.sym} 4970 2570 0 0 {name=M334
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 5110 2570 0 0 {name=M335
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 5110 2650 0 0 {name=M336
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {Local_encoder.sym} 4740 2460 0 0 {name=x56}
C {res.sym} -70 2820 0 0 {name=R113
value=500
footprint=1206
device=resistor
m=1}
C {res.sym} 110 2810 0 0 {name=R114
value=500
footprint=1206
device=resistor
m=1}
C {symbols/nfet_03v3.sym} -90 2910 0 0 {name=M337
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 130 2910 0 1 {name=M338
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} -40 2960 0 0 {name=l225 lab=GND}
C {gnd.sym} 80 2960 0 0 {name=l226 lab=GND}
C {gnd.sym} -40 3170 0 0 {name=l227 lab=GND}
C {symbols/nfet_03v3.sym} -60 3110 0 0 {name=M339
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} -100 3030 0 0 {name=p113 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} -100 3110 0 0 {name=p114 sig_type=std_logic lab=VBIAS}
C {gnd.sym} 100 3170 0 0 {name=l228 lab=GND}
C {symbols/nfet_03v3.sym} -60 3030 0 0 {name=M340
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 80 3030 0 0 {name=M341
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 80 3110 0 0 {name=M342
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {Local_encoder.sym} -290 2920 0 0 {name=x57}
C {res.sym} 690 2820 0 0 {name=R115
value=500
footprint=1206
device=resistor
m=1}
C {res.sym} 870 2810 0 0 {name=R116
value=500
footprint=1206
device=resistor
m=1}
C {symbols/nfet_03v3.sym} 670 2910 0 0 {name=M343
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 890 2910 0 1 {name=M344
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 720 2960 0 0 {name=l229 lab=GND}
C {gnd.sym} 840 2960 0 0 {name=l230 lab=GND}
C {gnd.sym} 720 3170 0 0 {name=l231 lab=GND}
C {symbols/nfet_03v3.sym} 700 3110 0 0 {name=M345
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 660 3030 0 0 {name=p115 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 660 3110 0 0 {name=p116 sig_type=std_logic lab=VBIAS}
C {gnd.sym} 860 3170 0 0 {name=l232 lab=GND}
C {symbols/nfet_03v3.sym} 700 3030 0 0 {name=M346
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 840 3030 0 0 {name=M347
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 840 3110 0 0 {name=M348
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {Local_encoder.sym} 470 2920 0 0 {name=x58}
C {res.sym} 1390 2820 0 0 {name=R117
value=500
footprint=1206
device=resistor
m=1}
C {res.sym} 1570 2810 0 0 {name=R118
value=500
footprint=1206
device=resistor
m=1}
C {symbols/nfet_03v3.sym} 1370 2910 0 0 {name=M349
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 1590 2910 0 1 {name=M350
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 1420 2960 0 0 {name=l233 lab=GND}
C {gnd.sym} 1540 2960 0 0 {name=l234 lab=GND}
C {gnd.sym} 1420 3170 0 0 {name=l235 lab=GND}
C {symbols/nfet_03v3.sym} 1400 3110 0 0 {name=M351
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 1360 3030 0 0 {name=p117 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 1360 3110 0 0 {name=p118 sig_type=std_logic lab=VBIAS}
C {gnd.sym} 1560 3170 0 0 {name=l236 lab=GND}
C {symbols/nfet_03v3.sym} 1400 3030 0 0 {name=M352
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 1540 3030 0 0 {name=M353
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 1540 3110 0 0 {name=M354
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {Local_encoder.sym} 1170 2920 0 0 {name=x59}
C {res.sym} 2120 2820 0 0 {name=R119
value=500
footprint=1206
device=resistor
m=1}
C {res.sym} 2300 2810 0 0 {name=R120
value=500
footprint=1206
device=resistor
m=1}
C {symbols/nfet_03v3.sym} 2100 2910 0 0 {name=M355
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2320 2910 0 1 {name=M356
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 2150 2960 0 0 {name=l237 lab=GND}
C {gnd.sym} 2270 2960 0 0 {name=l238 lab=GND}
C {gnd.sym} 2150 3170 0 0 {name=l239 lab=GND}
C {symbols/nfet_03v3.sym} 2130 3110 0 0 {name=M357
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 2090 3030 0 0 {name=p119 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 2090 3110 0 0 {name=p120 sig_type=std_logic lab=VBIAS}
C {gnd.sym} 2290 3170 0 0 {name=l240 lab=GND}
C {symbols/nfet_03v3.sym} 2130 3030 0 0 {name=M358
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2270 3030 0 0 {name=M359
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2270 3110 0 0 {name=M360
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {Local_encoder.sym} 1900 2920 0 0 {name=x60}
C {res.sym} 2840 2820 0 0 {name=R121
value=500
footprint=1206
device=resistor
m=1}
C {res.sym} 3020 2810 0 0 {name=R122
value=500
footprint=1206
device=resistor
m=1}
C {symbols/nfet_03v3.sym} 2820 2910 0 0 {name=M361
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 3040 2910 0 1 {name=M362
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 2870 2960 0 0 {name=l241 lab=GND}
C {gnd.sym} 2990 2960 0 0 {name=l242 lab=GND}
C {gnd.sym} 2870 3170 0 0 {name=l243 lab=GND}
C {symbols/nfet_03v3.sym} 2850 3110 0 0 {name=M363
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 2810 3030 0 0 {name=p121 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 2810 3110 0 0 {name=p122 sig_type=std_logic lab=VBIAS}
C {gnd.sym} 3010 3170 0 0 {name=l244 lab=GND}
C {symbols/nfet_03v3.sym} 2850 3030 0 0 {name=M364
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2990 3030 0 0 {name=M365
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2990 3110 0 0 {name=M366
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {Local_encoder.sym} 2620 2920 0 0 {name=x61}
C {res.sym} 3550 2820 0 0 {name=R123
value=500
footprint=1206
device=resistor
m=1}
C {res.sym} 3730 2810 0 0 {name=R124
value=500
footprint=1206
device=resistor
m=1}
C {symbols/nfet_03v3.sym} 3530 2910 0 0 {name=M367
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 3750 2910 0 1 {name=M368
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 3580 2960 0 0 {name=l245 lab=GND}
C {gnd.sym} 3700 2960 0 0 {name=l246 lab=GND}
C {gnd.sym} 3580 3170 0 0 {name=l247 lab=GND}
C {symbols/nfet_03v3.sym} 3560 3110 0 0 {name=M369
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3520 3030 0 0 {name=p123 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 3520 3110 0 0 {name=p124 sig_type=std_logic lab=VBIAS}
C {gnd.sym} 3720 3170 0 0 {name=l248 lab=GND}
C {symbols/nfet_03v3.sym} 3560 3030 0 0 {name=M370
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 3700 3030 0 0 {name=M371
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 3700 3110 0 0 {name=M372
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {Local_encoder.sym} 3330 2920 0 0 {name=x62}
C {res.sym} 4260 2820 0 0 {name=R125
value=500
footprint=1206
device=resistor
m=1}
C {res.sym} 4440 2810 0 0 {name=R126
value=500
footprint=1206
device=resistor
m=1}
C {symbols/nfet_03v3.sym} 4240 2910 0 0 {name=M373
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 4460 2910 0 1 {name=M374
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 4290 2960 0 0 {name=l249 lab=GND}
C {gnd.sym} 4410 2960 0 0 {name=l250 lab=GND}
C {gnd.sym} 4290 3170 0 0 {name=l251 lab=GND}
C {symbols/nfet_03v3.sym} 4270 3110 0 0 {name=M375
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4230 3030 0 0 {name=p125 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 4230 3110 0 0 {name=p126 sig_type=std_logic lab=VBIAS}
C {gnd.sym} 4430 3170 0 0 {name=l252 lab=GND}
C {symbols/nfet_03v3.sym} 4270 3030 0 0 {name=M376
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 4410 3030 0 0 {name=M377
L=0.28u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 4410 3110 0 0 {name=M378
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {Local_encoder.sym} 4040 2920 0 0 {name=x63}
C {thermometter_decoder.sym} -1080 -360 2 1 {name=x64}
C {vsource.sym} -680 -720 0 0 {name=V1 value=1.8 savecurrent=false}
C {lab_wire.sym} -680 -750 0 0 {name=p127 sig_type=std_logic lab=vdd}
C {gnd.sym} -680 -690 0 0 {name=l253 lab=GND}
C {lab_wire.sym} -250 -420 0 1 {name=p128 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 510 -420 0 1 {name=p129 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 1210 -420 0 1 {name=p130 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 1940 -420 0 1 {name=p131 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2660 -420 0 1 {name=p132 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 3370 -420 0 1 {name=p133 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 4080 -420 0 1 {name=p134 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 4780 -420 0 1 {name=p135 sig_type=std_logic lab=vdd}
C {lab_wire.sym} -440 -420 0 0 {name=p136 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 320 -420 0 0 {name=p137 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 1020 -420 0 0 {name=p138 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 1750 -420 0 0 {name=p139 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2470 -420 0 0 {name=p140 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 3180 -420 0 0 {name=p141 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 3890 -420 0 0 {name=p142 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 4590 -420 0 0 {name=p143 sig_type=std_logic lab=vdd}
C {lab_wire.sym} -840 -310 2 0 {name=p144 sig_type=std_logic lab=D7}
C {lab_wire.sym} -840 -330 2 0 {name=p145 sig_type=std_logic lab=D6}
C {lab_wire.sym} -840 -350 2 0 {name=p146 sig_type=std_logic lab=D5}
C {lab_wire.sym} -840 -370 2 0 {name=p147 sig_type=std_logic lab=D4}
C {lab_wire.sym} -840 -390 2 0 {name=p148 sig_type=std_logic lab=D3}
C {lab_wire.sym} -840 -410 2 0 {name=p149 sig_type=std_logic lab=D2}
C {lab_wire.sym} -840 -430 2 0 {name=p150 sig_type=std_logic lab=D1}
C {lab_wire.sym} -930 -290 2 0 {name=p151 sig_type=std_logic lab=vdd}
C {thermometter_decoder.sym} 130 -990 1 0 {name=x65}
C {lab_wire.sym} 60 -750 2 1 {name=p158 sig_type=std_logic lab=C1}
C {lab_wire.sym} 200 -840 1 1 {name=p159 sig_type=std_logic lab=vdd}
C {lab_wire.sym} -440 -360 3 0 {name=p161 sig_type=std_logic lab=CLK}
C {lab_wire.sym} -540 -400 3 1 {name=p162 sig_type=std_logic lab=D1}
C {lab_wire.sym} 250 -400 3 1 {name=p163 sig_type=std_logic lab=D1}
C {lab_wire.sym} 990 -400 3 1 {name=p164 sig_type=std_logic lab=D1}
C {lab_wire.sym} 1690 -400 3 1 {name=p165 sig_type=std_logic lab=D1}
C {lab_wire.sym} 2420 -400 3 1 {name=p166 sig_type=std_logic lab=D1}
C {lab_wire.sym} 3140 -400 3 1 {name=p167 sig_type=std_logic lab=D1}
C {lab_wire.sym} 3850 -400 3 1 {name=p169 sig_type=std_logic lab=D1}
C {lab_wire.sym} 4550 -400 3 1 {name=p170 sig_type=std_logic lab=D1}
C {lab_wire.sym} 80 -750 2 1 {name=p152 sig_type=std_logic lab=C2}
C {lab_wire.sym} 100 -750 2 1 {name=p153 sig_type=std_logic lab=C3}
C {lab_wire.sym} 120 -750 2 1 {name=p154 sig_type=std_logic lab=C4}
C {lab_wire.sym} 140 -750 2 1 {name=p155 sig_type=std_logic lab=C5}
C {lab_wire.sym} 160 -750 2 1 {name=p156 sig_type=std_logic lab=C6}
C {lab_wire.sym} 180 -750 2 1 {name=p157 sig_type=std_logic lab=C7}
C {lab_wire.sym} -540 -380 2 1 {name=p171 sig_type=std_logic lab=C1}
C {lab_wire.sym} 260 -380 2 1 {name=p172 sig_type=std_logic lab=C2}
C {lab_wire.sym} 990 -380 2 1 {name=p173 sig_type=std_logic lab=C3}
C {lab_wire.sym} 1700 -380 2 1 {name=p174 sig_type=std_logic lab=C4}
C {lab_wire.sym} 2430 -380 2 1 {name=p175 sig_type=std_logic lab=C5}
C {lab_wire.sym} 3150 -380 2 1 {name=p176 sig_type=std_logic lab=C6}
C {lab_wire.sym} 3860 -380 2 1 {name=p177 sig_type=std_logic lab=C7}
C {gnd.sym} 4570 -380 1 0 {name=l255 lab=GND}
C {lab_wire.sym} -460 40 0 0 {name=p179 sig_type=std_logic lab=D1}
C {lab_wire.sym} -460 60 0 0 {name=p178 sig_type=std_logic lab=D2}
C {lab_wire.sym} 290 40 0 0 {name=p180 sig_type=std_logic lab=D1}
C {lab_wire.sym} 290 60 0 0 {name=p181 sig_type=std_logic lab=D2}
C {lab_wire.sym} 990 40 0 0 {name=p182 sig_type=std_logic lab=D1}
C {lab_wire.sym} 990 60 0 0 {name=p183 sig_type=std_logic lab=D2}
C {lab_wire.sym} 1710 40 0 0 {name=p184 sig_type=std_logic lab=D1}
C {lab_wire.sym} 1710 60 0 0 {name=p185 sig_type=std_logic lab=D2}
C {lab_wire.sym} 2430 40 0 0 {name=p186 sig_type=std_logic lab=D1}
C {lab_wire.sym} 2430 60 0 0 {name=p187 sig_type=std_logic lab=D2}
C {lab_wire.sym} 3140 40 0 0 {name=p188 sig_type=std_logic lab=D1}
C {lab_wire.sym} 3140 60 0 0 {name=p189 sig_type=std_logic lab=D2}
C {lab_wire.sym} 3850 40 0 0 {name=p190 sig_type=std_logic lab=D1}
C {lab_wire.sym} 3850 60 0 0 {name=p191 sig_type=std_logic lab=D2}
C {lab_wire.sym} 4560 60 0 0 {name=p192 sig_type=std_logic lab=D1}
C {lab_wire.sym} 4560 80 0 0 {name=p193 sig_type=std_logic lab=D2}
C {gnd.sym} 4570 150 0 0 {name=l256 lab=GND}
C {lab_wire.sym} -460 80 0 0 {name=p194 sig_type=std_logic lab=C1}
C {lab_wire.sym} 290 80 0 0 {name=p195 sig_type=std_logic lab=C2}
C {lab_wire.sym} 990 80 0 0 {name=p196 sig_type=std_logic lab=C3}
C {lab_wire.sym} 1710 80 0 0 {name=p197 sig_type=std_logic lab=C4}
C {lab_wire.sym} 2430 80 0 0 {name=p198 sig_type=std_logic lab=C5}
C {lab_wire.sym} 3150 80 0 0 {name=p199 sig_type=std_logic lab=C6}
C {lab_wire.sym} 3860 80 0 0 {name=p200 sig_type=std_logic lab=C7}
C {lab_wire.sym} -480 490 0 0 {name=p201 sig_type=std_logic lab=D2}
C {lab_wire.sym} -480 510 0 0 {name=p202 sig_type=std_logic lab=D3}
C {lab_wire.sym} -480 530 0 0 {name=p203 sig_type=std_logic lab=C1}
C {lab_wire.sym} 280 490 0 0 {name=p204 sig_type=std_logic lab=D2}
C {lab_wire.sym} 280 510 0 0 {name=p205 sig_type=std_logic lab=D3}
C {lab_wire.sym} 280 530 0 0 {name=p206 sig_type=std_logic lab=C2}
C {lab_wire.sym} 990 490 0 0 {name=p207 sig_type=std_logic lab=D2}
C {lab_wire.sym} 990 510 0 0 {name=p208 sig_type=std_logic lab=D3}
C {lab_wire.sym} 990 530 0 0 {name=p209 sig_type=std_logic lab=C3}
C {lab_wire.sym} 1710 490 0 0 {name=p210 sig_type=std_logic lab=D2}
C {lab_wire.sym} 1710 510 0 0 {name=p211 sig_type=std_logic lab=D3}
C {lab_wire.sym} 1710 530 0 0 {name=p212 sig_type=std_logic lab=C4}
C {lab_wire.sym} 2440 490 0 0 {name=p213 sig_type=std_logic lab=D2}
C {lab_wire.sym} 2440 510 0 0 {name=p214 sig_type=std_logic lab=D3}
C {lab_wire.sym} 2440 530 0 0 {name=p215 sig_type=std_logic lab=C5}
C {lab_wire.sym} 3140 490 0 0 {name=p216 sig_type=std_logic lab=D2}
C {lab_wire.sym} 3140 510 0 0 {name=p217 sig_type=std_logic lab=D3}
C {lab_wire.sym} 3140 530 0 0 {name=p218 sig_type=std_logic lab=C6}
C {lab_wire.sym} 3850 490 0 0 {name=p219 sig_type=std_logic lab=D2}
C {lab_wire.sym} 3850 510 0 0 {name=p220 sig_type=std_logic lab=D3}
C {lab_wire.sym} 3850 530 0 0 {name=p221 sig_type=std_logic lab=C7}
C {lab_wire.sym} 4560 490 0 0 {name=p222 sig_type=std_logic lab=D2}
C {lab_wire.sym} 4560 510 0 0 {name=p223 sig_type=std_logic lab=D3}
C {gnd.sym} 4570 580 0 0 {name=l257 lab=GND}
C {lab_wire.sym} -480 1000 0 0 {name=p224 sig_type=std_logic lab=D3}
C {lab_wire.sym} -480 1020 0 0 {name=p225 sig_type=std_logic lab=D4}
C {lab_wire.sym} -480 1040 0 0 {name=p226 sig_type=std_logic lab=C1}
C {lab_wire.sym} 280 1000 0 0 {name=p227 sig_type=std_logic lab=D3}
C {lab_wire.sym} 280 1020 0 0 {name=p228 sig_type=std_logic lab=D4}
C {lab_wire.sym} 280 1040 0 0 {name=p229 sig_type=std_logic lab=C2}
C {lab_wire.sym} 990 1000 0 0 {name=p230 sig_type=std_logic lab=D3}
C {lab_wire.sym} 990 1020 0 0 {name=p231 sig_type=std_logic lab=D4}
C {lab_wire.sym} 990 1040 0 0 {name=p232 sig_type=std_logic lab=C3}
C {lab_wire.sym} 1720 1000 0 0 {name=p233 sig_type=std_logic lab=D3}
C {lab_wire.sym} 1720 1020 0 0 {name=p234 sig_type=std_logic lab=D4}
C {lab_wire.sym} 1720 1040 0 0 {name=p235 sig_type=std_logic lab=C4}
C {lab_wire.sym} 2440 1000 0 0 {name=p236 sig_type=std_logic lab=D3}
C {lab_wire.sym} 2440 1020 0 0 {name=p237 sig_type=std_logic lab=D4}
C {lab_wire.sym} 2440 1040 0 0 {name=p238 sig_type=std_logic lab=C5}
C {lab_wire.sym} 3150 1000 0 0 {name=p239 sig_type=std_logic lab=D3}
C {lab_wire.sym} 3150 1020 0 0 {name=p240 sig_type=std_logic lab=D4}
C {lab_wire.sym} 3150 1040 0 0 {name=p241 sig_type=std_logic lab=C6}
C {lab_wire.sym} 3860 1000 0 0 {name=p242 sig_type=std_logic lab=D3}
C {lab_wire.sym} 3860 1020 0 0 {name=p243 sig_type=std_logic lab=D4}
C {lab_wire.sym} 3860 1040 0 0 {name=p244 sig_type=std_logic lab=C7}
C {lab_wire.sym} 4560 1000 0 0 {name=p245 sig_type=std_logic lab=D3}
C {lab_wire.sym} 4560 1020 0 0 {name=p246 sig_type=std_logic lab=D4}
C {gnd.sym} 4570 1040 1 0 {name=l258 lab=GND}
C {lab_wire.sym} -480 1470 0 0 {name=p247 sig_type=std_logic lab=D4}
C {lab_wire.sym} -480 1490 0 0 {name=p248 sig_type=std_logic lab=D5}
C {lab_wire.sym} -480 1510 0 0 {name=p249 sig_type=std_logic lab=C1}
C {lab_wire.sym} 280 1470 0 0 {name=p250 sig_type=std_logic lab=D4}
C {lab_wire.sym} 280 1490 0 0 {name=p251 sig_type=std_logic lab=D5}
C {lab_wire.sym} 280 1510 0 0 {name=p252 sig_type=std_logic lab=C2}
C {lab_wire.sym} 1000 1470 0 0 {name=p253 sig_type=std_logic lab=D4}
C {lab_wire.sym} 1000 1490 0 0 {name=p254 sig_type=std_logic lab=D5}
C {lab_wire.sym} 1000 1510 0 0 {name=p255 sig_type=std_logic lab=C3}
C {lab_wire.sym} 1730 1470 0 0 {name=p256 sig_type=std_logic lab=D4}
C {lab_wire.sym} 1730 1490 0 0 {name=p257 sig_type=std_logic lab=D5}
C {lab_wire.sym} 1730 1510 0 0 {name=p258 sig_type=std_logic lab=C4}
C {lab_wire.sym} 2450 1470 0 0 {name=p259 sig_type=std_logic lab=D4}
C {lab_wire.sym} 2450 1490 0 0 {name=p260 sig_type=std_logic lab=D5}
C {lab_wire.sym} 2450 1510 0 0 {name=p261 sig_type=std_logic lab=C5}
C {lab_wire.sym} 3160 1470 0 0 {name=p262 sig_type=std_logic lab=D4}
C {lab_wire.sym} 3160 1490 0 0 {name=p263 sig_type=std_logic lab=D5}
C {lab_wire.sym} 3160 1510 0 0 {name=p264 sig_type=std_logic lab=C6}
C {lab_wire.sym} 3870 1470 0 0 {name=p265 sig_type=std_logic lab=D4}
C {lab_wire.sym} 3870 1490 0 0 {name=p266 sig_type=std_logic lab=D5}
C {lab_wire.sym} 3870 1510 0 0 {name=p267 sig_type=std_logic lab=C7}
C {lab_wire.sym} 4570 1470 0 0 {name=p268 sig_type=std_logic lab=D4}
C {lab_wire.sym} 4570 1490 0 0 {name=p269 sig_type=std_logic lab=D5}
C {gnd.sym} 4570 1510 1 0 {name=l259 lab=GND}
C {lab_wire.sym} -480 1970 0 0 {name=p271 sig_type=std_logic lab=D5}
C {lab_wire.sym} -480 2010 0 0 {name=p272 sig_type=std_logic lab=C1}
C {lab_wire.sym} -480 1990 0 0 {name=p270 sig_type=std_logic lab=D6}
C {lab_wire.sym} 280 1970 0 0 {name=p273 sig_type=std_logic lab=D5}
C {lab_wire.sym} 280 2010 0 0 {name=p274 sig_type=std_logic lab=C2}
C {lab_wire.sym} 280 1990 0 0 {name=p275 sig_type=std_logic lab=D6}
C {lab_wire.sym} 980 1970 0 0 {name=p276 sig_type=std_logic lab=D5}
C {lab_wire.sym} 980 2010 0 0 {name=p277 sig_type=std_logic lab=C3}
C {lab_wire.sym} 980 1990 0 0 {name=p278 sig_type=std_logic lab=D6}
C {lab_wire.sym} 1710 1970 0 0 {name=p279 sig_type=std_logic lab=D5}
C {lab_wire.sym} 1710 2010 0 0 {name=p280 sig_type=std_logic lab=C4}
C {lab_wire.sym} 1710 1990 0 0 {name=p281 sig_type=std_logic lab=D6}
C {lab_wire.sym} 2430 1970 0 0 {name=p282 sig_type=std_logic lab=D5}
C {lab_wire.sym} 2430 2010 0 0 {name=p283 sig_type=std_logic lab=C5}
C {lab_wire.sym} 2430 1990 0 0 {name=p284 sig_type=std_logic lab=D6}
C {lab_wire.sym} 3140 1970 0 0 {name=p285 sig_type=std_logic lab=D5}
C {lab_wire.sym} 3140 2010 0 0 {name=p286 sig_type=std_logic lab=C6}
C {lab_wire.sym} 3140 1990 0 0 {name=p287 sig_type=std_logic lab=D6}
C {lab_wire.sym} 3850 1970 0 0 {name=p288 sig_type=std_logic lab=D5}
C {lab_wire.sym} 3850 2010 0 0 {name=p289 sig_type=std_logic lab=C7}
C {lab_wire.sym} 3850 1990 0 0 {name=p290 sig_type=std_logic lab=D6}
C {lab_wire.sym} 4550 1970 0 0 {name=p291 sig_type=std_logic lab=D5}
C {lab_wire.sym} 4550 1990 0 0 {name=p293 sig_type=std_logic lab=D6}
C {gnd.sym} 4560 2010 1 0 {name=l260 lab=GND}
C {lab_wire.sym} -480 2430 0 0 {name=p292 sig_type=std_logic lab=D6}
C {lab_wire.sym} -480 2470 0 0 {name=p294 sig_type=std_logic lab=C1}
C {lab_wire.sym} -480 2450 0 0 {name=p295 sig_type=std_logic lab=D7}
C {lab_wire.sym} 280 2430 0 0 {name=p296 sig_type=std_logic lab=D6}
C {lab_wire.sym} 280 2470 0 0 {name=p297 sig_type=std_logic lab=C2}
C {lab_wire.sym} 280 2450 0 0 {name=p298 sig_type=std_logic lab=D7}
C {lab_wire.sym} 980 2430 0 0 {name=p299 sig_type=std_logic lab=D6}
C {lab_wire.sym} 980 2470 0 0 {name=p300 sig_type=std_logic lab=C3}
C {lab_wire.sym} 980 2450 0 0 {name=p301 sig_type=std_logic lab=D7}
C {lab_wire.sym} 1710 2430 0 0 {name=p302 sig_type=std_logic lab=D6}
C {lab_wire.sym} 1710 2470 0 0 {name=p303 sig_type=std_logic lab=C4}
C {lab_wire.sym} 1710 2450 0 0 {name=p304 sig_type=std_logic lab=D7}
C {lab_wire.sym} 2430 2430 0 0 {name=p305 sig_type=std_logic lab=D6}
C {lab_wire.sym} 2430 2470 0 0 {name=p306 sig_type=std_logic lab=C5}
C {lab_wire.sym} 2430 2450 0 0 {name=p307 sig_type=std_logic lab=D7}
C {lab_wire.sym} 3140 2430 0 0 {name=p308 sig_type=std_logic lab=D6}
C {lab_wire.sym} 3140 2470 0 0 {name=p309 sig_type=std_logic lab=C6}
C {lab_wire.sym} 3140 2450 0 0 {name=p310 sig_type=std_logic lab=D7}
C {lab_wire.sym} 3850 2430 0 0 {name=p311 sig_type=std_logic lab=D6}
C {lab_wire.sym} 3850 2470 0 0 {name=p312 sig_type=std_logic lab=C7}
C {lab_wire.sym} 3850 2450 0 0 {name=p313 sig_type=std_logic lab=D7}
C {lab_wire.sym} 4550 2430 0 0 {name=p314 sig_type=std_logic lab=D6}
C {lab_wire.sym} 4550 2450 0 0 {name=p316 sig_type=std_logic lab=D7}
C {gnd.sym} 4560 2520 0 0 {name=l261 lab=GND}
C {lab_wire.sym} -480 2890 0 0 {name=p315 sig_type=std_logic lab=D7}
C {lab_wire.sym} -480 2930 0 0 {name=p317 sig_type=std_logic lab=C1}
C {gnd.sym} -470 2990 0 0 {name=l262 lab=GND}
C {lab_wire.sym} 290 2890 0 0 {name=p318 sig_type=std_logic lab=D7}
C {lab_wire.sym} 290 2930 0 0 {name=p319 sig_type=std_logic lab=C2}
C {gnd.sym} 300 2980 0 0 {name=l263 lab=GND}
C {lab_wire.sym} 980 2890 0 0 {name=p320 sig_type=std_logic lab=D7}
C {lab_wire.sym} 980 2930 0 0 {name=p321 sig_type=std_logic lab=C3}
C {gnd.sym} 1000 3000 0 0 {name=l264 lab=GND}
C {lab_wire.sym} 1710 2890 0 0 {name=p322 sig_type=std_logic lab=D7}
C {lab_wire.sym} 1710 2930 0 0 {name=p323 sig_type=std_logic lab=C4}
C {gnd.sym} 1720 3000 0 0 {name=l265 lab=GND}
C {lab_wire.sym} 2430 2890 0 0 {name=p324 sig_type=std_logic lab=D7}
C {lab_wire.sym} 2430 2930 0 0 {name=p325 sig_type=std_logic lab=C5}
C {gnd.sym} 2450 3000 0 0 {name=l266 lab=GND}
C {lab_wire.sym} 3140 2890 0 0 {name=p326 sig_type=std_logic lab=D7}
C {lab_wire.sym} 3140 2930 0 0 {name=p327 sig_type=std_logic lab=C6}
C {gnd.sym} 3160 2990 0 0 {name=l267 lab=GND}
C {lab_wire.sym} 3850 2890 0 0 {name=p328 sig_type=std_logic lab=D7}
C {lab_wire.sym} 3850 2930 0 0 {name=p329 sig_type=std_logic lab=C7}
C {gnd.sym} 3870 2980 0 0 {name=l268 lab=GND}
C {lab_wire.sym} -480 2950 0 0 {name=p330 sig_type=std_logic lab=CLK}
C {lab_wire.sym} 290 2950 0 0 {name=p331 sig_type=std_logic lab=CLK}
C {lab_wire.sym} 990 2950 0 0 {name=p332 sig_type=std_logic lab=CLK}
C {lab_wire.sym} 1710 2950 0 0 {name=p333 sig_type=std_logic lab=CLK}
C {lab_wire.sym} -250 2890 0 1 {name=p334 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 510 2890 0 1 {name=p335 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 1210 2890 0 1 {name=p336 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 1940 2890 0 1 {name=p337 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2660 2890 0 1 {name=p338 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2440 2950 0 0 {name=p339 sig_type=std_logic lab=CLK}
C {lab_wire.sym} 3370 2890 0 1 {name=p340 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 3150 2950 0 0 {name=p341 sig_type=std_logic lab=CLK}
C {lab_wire.sym} 4080 2890 0 1 {name=p342 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 3860 2950 0 0 {name=p343 sig_type=std_logic lab=CLK}
C {lab_wire.sym} -480 2490 0 0 {name=p344 sig_type=std_logic lab=CLK}
C {lab_wire.sym} -250 2430 0 1 {name=p345 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 280 2490 0 0 {name=p346 sig_type=std_logic lab=CLK}
C {lab_wire.sym} 510 2430 0 1 {name=p347 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 980 2490 0 0 {name=p348 sig_type=std_logic lab=CLK}
C {lab_wire.sym} 1210 2430 0 1 {name=p349 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 1710 2490 0 0 {name=p350 sig_type=std_logic lab=CLK}
C {lab_wire.sym} 1940 2430 0 1 {name=p351 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2430 2490 0 0 {name=p352 sig_type=std_logic lab=CLK}
C {lab_wire.sym} 2660 2430 0 1 {name=p353 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 3140 2490 0 0 {name=p354 sig_type=std_logic lab=CLK}
C {lab_wire.sym} 3370 2430 0 1 {name=p355 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 3850 2490 0 0 {name=p356 sig_type=std_logic lab=CLK}
C {lab_wire.sym} 4080 2430 0 1 {name=p357 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 4550 2490 0 0 {name=p358 sig_type=std_logic lab=CLK}
C {lab_wire.sym} 4780 2430 0 1 {name=p359 sig_type=std_logic lab=vdd}
C {lab_wire.sym} -480 2030 0 0 {name=p360 sig_type=std_logic lab=CLK}
C {lab_wire.sym} -250 1970 0 1 {name=p361 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 280 2030 0 0 {name=p362 sig_type=std_logic lab=CLK}
C {lab_wire.sym} 510 1970 0 1 {name=p363 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 980 2030 0 0 {name=p364 sig_type=std_logic lab=CLK}
C {lab_wire.sym} 1210 1970 0 1 {name=p365 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 1710 2030 0 0 {name=p366 sig_type=std_logic lab=CLK}
C {lab_wire.sym} 1940 1970 0 1 {name=p367 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2430 2030 0 0 {name=p368 sig_type=std_logic lab=CLK}
C {lab_wire.sym} 2660 1970 0 1 {name=p369 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 3140 2030 0 0 {name=p370 sig_type=std_logic lab=CLK}
C {lab_wire.sym} 3370 1970 0 1 {name=p371 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 3850 2030 0 0 {name=p372 sig_type=std_logic lab=CLK}
C {lab_wire.sym} 4080 1970 0 1 {name=p373 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 4550 2030 0 0 {name=p374 sig_type=std_logic lab=CLK}
C {lab_wire.sym} 4780 1970 0 1 {name=p375 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 4550 1530 0 0 {name=p376 sig_type=std_logic lab=CLK}
C {lab_wire.sym} 4780 1470 0 1 {name=p377 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 3850 1530 0 0 {name=p378 sig_type=std_logic lab=CLK}
C {lab_wire.sym} 4080 1470 0 1 {name=p379 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 3140 1530 0 0 {name=p380 sig_type=std_logic lab=CLK}
C {lab_wire.sym} 3370 1470 0 1 {name=p381 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2430 1530 0 0 {name=p382 sig_type=std_logic lab=CLK}
C {lab_wire.sym} 2660 1470 0 1 {name=p383 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 1710 1530 0 0 {name=p384 sig_type=std_logic lab=CLK}
C {lab_wire.sym} 1940 1470 0 1 {name=p385 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 980 1530 0 0 {name=p386 sig_type=std_logic lab=CLK}
C {lab_wire.sym} 1210 1470 0 1 {name=p387 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 280 1530 0 0 {name=p388 sig_type=std_logic lab=CLK}
C {lab_wire.sym} 510 1470 0 1 {name=p389 sig_type=std_logic lab=vdd}
C {lab_wire.sym} -480 1530 0 0 {name=p390 sig_type=std_logic lab=CLK}
C {lab_wire.sym} -250 1470 0 1 {name=p391 sig_type=std_logic lab=vdd}
C {lab_wire.sym} -480 1060 0 0 {name=p392 sig_type=std_logic lab=CLK}
C {lab_wire.sym} -250 1000 0 1 {name=p393 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 280 1060 0 0 {name=p394 sig_type=std_logic lab=CLK}
C {lab_wire.sym} 510 1000 0 1 {name=p395 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 980 1060 0 0 {name=p396 sig_type=std_logic lab=CLK}
C {lab_wire.sym} 1210 1000 0 1 {name=p397 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 1710 1060 0 0 {name=p398 sig_type=std_logic lab=CLK}
C {lab_wire.sym} 1940 1000 0 1 {name=p399 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2430 1060 0 0 {name=p400 sig_type=std_logic lab=CLK}
C {lab_wire.sym} 2660 1000 0 1 {name=p401 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 3140 1060 0 0 {name=p402 sig_type=std_logic lab=CLK}
C {lab_wire.sym} 3370 1000 0 1 {name=p403 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 3850 1060 0 0 {name=p404 sig_type=std_logic lab=CLK}
C {lab_wire.sym} 4080 1000 0 1 {name=p405 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 4550 1060 0 0 {name=p406 sig_type=std_logic lab=CLK}
C {lab_wire.sym} 4780 1000 0 1 {name=p407 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 4560 550 0 0 {name=p408 sig_type=std_logic lab=CLK}
C {lab_wire.sym} 4780 490 0 1 {name=p409 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 3850 550 0 0 {name=p410 sig_type=std_logic lab=CLK}
C {lab_wire.sym} 4080 490 0 1 {name=p411 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 3140 550 0 0 {name=p412 sig_type=std_logic lab=CLK}
C {lab_wire.sym} 3370 490 0 1 {name=p413 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2430 550 0 0 {name=p414 sig_type=std_logic lab=CLK}
C {lab_wire.sym} 2660 490 0 1 {name=p415 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 1710 550 0 0 {name=p416 sig_type=std_logic lab=CLK}
C {lab_wire.sym} 1940 490 0 1 {name=p417 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 980 550 0 0 {name=p418 sig_type=std_logic lab=CLK}
C {lab_wire.sym} 1210 490 0 1 {name=p419 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 280 550 0 0 {name=p420 sig_type=std_logic lab=CLK}
C {lab_wire.sym} 510 490 0 1 {name=p421 sig_type=std_logic lab=vdd}
C {lab_wire.sym} -480 550 0 0 {name=p422 sig_type=std_logic lab=CLK}
C {lab_wire.sym} -250 490 0 1 {name=p423 sig_type=std_logic lab=vdd}
C {lab_wire.sym} -480 100 0 0 {name=p424 sig_type=std_logic lab=CLK}
C {lab_wire.sym} -250 40 0 1 {name=p425 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 280 100 0 0 {name=p426 sig_type=std_logic lab=CLK}
C {lab_wire.sym} 510 40 0 1 {name=p427 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 980 100 0 0 {name=p428 sig_type=std_logic lab=CLK}
C {lab_wire.sym} 1210 40 0 1 {name=p429 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 1710 100 0 0 {name=p430 sig_type=std_logic lab=CLK}
C {lab_wire.sym} 1940 40 0 1 {name=p431 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2430 100 0 0 {name=p432 sig_type=std_logic lab=CLK}
C {lab_wire.sym} 2660 40 0 1 {name=p433 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 3140 100 0 0 {name=p434 sig_type=std_logic lab=CLK}
C {lab_wire.sym} 3370 40 0 1 {name=p435 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 3850 100 0 0 {name=p436 sig_type=std_logic lab=CLK}
C {lab_wire.sym} 4080 40 0 1 {name=p437 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 4550 120 0 0 {name=p438 sig_type=std_logic lab=CLK}
C {lab_wire.sym} 4780 60 0 1 {name=p439 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 320 -360 3 0 {name=p440 sig_type=std_logic lab=CLK}
C {lab_wire.sym} 1020 -360 3 0 {name=p441 sig_type=std_logic lab=CLK}
C {lab_wire.sym} 1750 -360 3 0 {name=p442 sig_type=std_logic lab=CLK}
C {lab_wire.sym} 2470 -360 3 0 {name=p443 sig_type=std_logic lab=CLK}
C {lab_wire.sym} 3180 -360 3 0 {name=p444 sig_type=std_logic lab=CLK}
C {lab_wire.sym} 3890 -360 3 0 {name=p445 sig_type=std_logic lab=CLK}
C {lab_wire.sym} 4590 -360 3 0 {name=p446 sig_type=std_logic lab=CLK}
C {res.sym} 5450 -810 0 0 {name=R127
value=0
footprint=1206
device=resistor
m=1}
C {res.sym} 5600 -810 0 0 {name=R128
value=0
footprint=1206
device=resistor
m=1}
C {code_shown.sym} -250 -1390 0 0 {name=NGSPICE only_toplevel=false value=".tran 1n 5120n
.save @R127[i]
.save @R128[i]
.save @R133[i]
.save @R135[i]
.save @R131[i]
.save @R9[i]
.save all"}
C {devices/code_shown.sym} -280 -1500 0 0 {name=MODELS only_toplevel=true
format="tcleval( @value )"
value="
.include $PDK_ROOT/gf180mcuC/libs.tech/ngspice/design.ngspice
.lib $PDK_ROOT/gf180mcuC/libs.tech/ngspice/sm141064.ngspice typical
"}
C {lab_wire.sym} 5450 -960 0 0 {name=p447 sig_type=std_logic lab=xxx}
C {lab_wire.sym} 5600 -960 0 0 {name=p448 sig_type=std_logic lab=xxx}
C {vsource.sym} -380 -740 0 0 {name=V3 value=3 savecurrent=false}
C {lab_wire.sym} -380 -770 0 0 {name=p449 sig_type=std_logic lab=xxx}
C {gnd.sym} -380 -710 0 0 {name=l269 lab=GND}
C {vsource.sym} -670 -860 0 0 {name=V10 value=1.8 savecurrent=false}
C {lab_wire.sym} -670 -890 0 0 {name=p462 sig_type=std_logic lab=VBIAS}
C {gnd.sym} -670 -830 0 0 {name=l276 lab=GND}
C {vsource.sym} -1200 -140 0 0 {name=V2 value="PULSE(0 1.8 0 1n 1n 4n 10n)" savecurrent=false}
C {lab_wire.sym} -1200 -170 0 0 {name=p160 sig_type=std_logic lab=X1}
C {gnd.sym} -1200 -110 0 0 {name=l254 lab=GND}
C {vsource.sym} -750 -130 0 0 {name=V4 value="PULSE(0 1.8 0 1n 1n 4n 10n)" savecurrent=false}
C {lab_wire.sym} -750 -160 0 0 {name=p456 sig_type=std_logic lab=CLK}
C {gnd.sym} -750 -100 0 0 {name=l270 lab=GND}
C {vsource.sym} -980 -140 0 0 {name=V5 value="PULSE(0 1.8 0 1n 1n 9n 20n)" savecurrent=false}
C {lab_wire.sym} -980 -170 0 0 {name=p458 sig_type=std_logic lab=X2}
C {gnd.sym} -980 -110 0 0 {name=l272 lab=GND}
C {vsource.sym} -1200 -30 0 0 {name=V6 value="PULSE(0 1.8 0 1n 1n 19n 40n)" savecurrent=false}
C {lab_wire.sym} -1200 -60 0 0 {name=p459 sig_type=std_logic lab=X3}
C {gnd.sym} -1200 0 0 0 {name=l273 lab=GND}
C {vsource.sym} -970 -20 0 0 {name=V7 value="PULSE(0 1.8 0 1n 1n 39n 80n)" savecurrent=false}
C {lab_wire.sym} -970 -50 0 0 {name=p460 sig_type=std_logic lab=X4}
C {gnd.sym} -970 10 0 0 {name=l274 lab=GND}
C {vsource.sym} -1200 90 0 0 {name=V8 value="PULSE(0 1.8 0 1n 1n 79n 160n)" savecurrent=false}
C {lab_wire.sym} -1200 60 0 0 {name=p461 sig_type=std_logic lab=X5}
C {gnd.sym} -1200 120 0 0 {name=l275 lab=GND}
C {vsource.sym} -970 90 0 0 {name=V9 value="PULSE(0 1.8 0 1n 1n 159n 320n)" savecurrent=false}
C {lab_wire.sym} -970 60 0 0 {name=p489 sig_type=std_logic lab=X6}
C {gnd.sym} -970 120 0 0 {name=l292 lab=GND}
C {lab_wire.sym} 200 -1200 0 1 {name=p168 sig_type=std_logic lab=X5}
C {lab_wire.sym} 180 -1200 0 1 {name=p450 sig_type=std_logic lab=X6}
C {lab_wire.sym} 160 -1200 0 1 {name=p451 sig_type=std_logic lab=X7}
C {lab_wire.sym} -1280 -290 0 0 {name=p452 sig_type=std_logic lab=X8}
C {lab_wire.sym} -1280 -310 0 0 {name=p453 sig_type=std_logic lab=X9}
C {lab_wire.sym} -1280 -330 0 0 {name=p454 sig_type=std_logic lab=X10}
C {vsource.sym} -1200 200 0 0 {name=V11 value="PULSE(0 1.8 0 1n 1n 319n 640n)" savecurrent=false}
C {lab_wire.sym} -1200 170 0 0 {name=p490 sig_type=std_logic lab=X7}
C {gnd.sym} -1200 230 0 0 {name=l293 lab=GND}
C {vsource.sym} -970 200 0 0 {name=V12 value="PULSE(0 1.8 0 1n 1n 639n 1280n)" savecurrent=false}
C {lab_wire.sym} -970 170 0 0 {name=p491 sig_type=std_logic lab=X8}
C {gnd.sym} -970 230 0 0 {name=l294 lab=GND}
C {vsource.sym} -1200 320 0 0 {name=V13 value="PULSE(0 1.8 0 1n 1n 1279n 2560n)" savecurrent=false}
C {lab_wire.sym} -1200 290 0 0 {name=p492 sig_type=std_logic lab=X9}
C {gnd.sym} -1200 350 0 0 {name=l295 lab=GND}
C {vsource.sym} -960 320 0 0 {name=V14 value="PULSE(0 1.8 0 1n 1n 2559n 5120n)" savecurrent=false}
C {lab_wire.sym} -960 290 0 0 {name=p493 sig_type=std_logic lab=X10}
C {gnd.sym} -960 350 0 0 {name=l296 lab=GND}
C {symbols/nfet_03v3.sym} 3530 60 0 0 {name=M397
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {vsource.sym} -550 -810 0 0 {name=V15 value=1.8 savecurrent=false}
C {lab_wire.sym} -550 -840 0 0 {name=p494 sig_type=std_logic lab=vcc}
C {gnd.sym} -550 -780 0 0 {name=l288 lab=GND}
C {symbols/nfet_03v3.sym} 9640 -40 0 1 {name=M79
L=0.28u
W=0.22u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 9240 -40 0 0 {name=M379
L=0.28u
W=0.22u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {res.sym} 9620 -290 0 1 {name=R129
value=500
footprint=1206
device=resistor
m=1}
C {res.sym} 9260 -300 0 1 {name=R130
value=500
footprint=1206
device=resistor
m=1}
C {gnd.sym} 9570 30 0 1 {name=l271 lab=GND}
C {gnd.sym} 9300 20 0 1 {name=l277 lab=GND}
C {symbols/nfet_03v3.sym} 9450 140 0 1 {name=M380
L=0.28u
W=0.22u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 9450 230 0 1 {name=M381
L=2.2u
W=0.22u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 9530 140 0 1 {name=p455 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 9530 230 0 1 {name=p457 sig_type=std_logic lab=VBIAS}
C {gnd.sym} 9430 300 0 1 {name=l278 lab=GND}
C {gnd.sym} 8760 30 0 1 {name=l279 lab=GND}
C {gnd.sym} 8490 20 0 1 {name=l280 lab=GND}
C {symbols/nfet_03v3.sym} 8640 140 0 1 {name=M382
L=0.28u
W=0.22u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 8720 140 0 1 {name=p463 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 8720 230 0 1 {name=p464 sig_type=std_logic lab=VBIAS}
C {gnd.sym} 8620 300 0 1 {name=l281 lab=GND}
C {res.sym} 8810 -200 0 1 {name=R131
value=500
footprint=1206
device=resistor
m=1}
C {res.sym} 8450 -200 0 1 {name=R132
value=500
footprint=1206
device=resistor
m=1}
C {gnd.sym} 7970 30 0 1 {name=l282 lab=GND}
C {gnd.sym} 7700 20 0 1 {name=l283 lab=GND}
C {lab_wire.sym} 8020 110 0 1 {name=p465 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 8020 200 0 1 {name=p466 sig_type=std_logic lab=VBIAS}
C {gnd.sym} 7920 270 0 1 {name=l284 lab=GND}
C {res.sym} 8020 -200 0 1 {name=R133
value=500
footprint=1206
device=resistor
m=1}
C {res.sym} 7660 -200 0 1 {name=R134
value=500
footprint=1206
device=resistor
m=1}
C {gnd.sym} 7740 270 0 1 {name=l285 lab=GND}
C {symbols/nfet_03v3.sym} 8830 -40 0 1 {name=M383
L=0.28u
W=0.22u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 8430 -40 0 0 {name=M384
L=0.28u
W=0.22u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 7640 -40 0 0 {name=M385
L=0.28u
W=0.22u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 8040 -40 0 1 {name=M386
L=0.28u
W=0.22u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 8640 230 0 1 {name=M387
L=1.8u
W=0.52u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 7940 110 0 1 {name=M388
L=0.28u
W=0.22u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 7760 110 0 1 {name=M389
L=0.28u
W=0.22u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 9410 530 0 0 {name=p469 sig_type=std_logic lab=vcc
}
C {lab_wire.sym} 8580 500 0 0 {name=p470 sig_type=std_logic lab=vcc
}
C {lab_wire.sym} 7780 480 0 0 {name=p471 sig_type=std_logic lab=vcc
}
C {lab_wire.sym} 8580 800 0 0 {name=p472 sig_type=std_logic lab=X2
}
C {lab_wire.sym} 9430 830 0 1 {name=p473 sig_type=std_logic lab=CLK
}
C {lab_wire.sym} 8600 800 0 1 {name=p474 sig_type=std_logic lab=CLK
}
C {lab_wire.sym} 7800 780 0 1 {name=p475 sig_type=std_logic lab=CLK
}
C {symbols/nfet_03v3.sym} 7940 200 0 1 {name=M390
L=1.4u
W=0.6u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 7760 200 0 1 {name=M391
L=1.4u
W=0.6u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 7310 -40 0 1 {name=M392
L=0.28u
W=0.66u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 6910 -40 0 0 {name=M393
L=0.28u
W=0.66u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {gnd.sym} 7260 10 0 1 {name=l286 lab=GND}
C {gnd.sym} 6960 10 0 1 {name=l287 lab=GND}
C {lab_wire.sym} 7050 480 0 0 {name=p482 sig_type=std_logic lab=vcc
}
C {lab_wire.sym} 7070 780 0 1 {name=p483 sig_type=std_logic lab=CLK
}
C {lab_wire.sym} 7050 780 3 1 {name=p484 sig_type=std_logic lab=X4
}
C {gnd.sym} 6970 140 0 1 {name=l290 lab=GND}
C {gnd.sym} 6970 220 0 1 {name=l291 lab=GND}
C {gnd.sym} 7090 280 0 1 {name=l297 lab=GND}
C {symbols/nfet_03v3.sym} 7110 220 0 1 {name=M394
L=0.28u
W=0.86u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 7110 140 0 1 {name=M395
L=0.28u
W=0.66u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 9410 830 0 0 {name=p485 sig_type=std_logic lab=X1
}
C {lab_wire.sym} 7780 780 0 0 {name=p486 sig_type=std_logic lab=X3
}
C {res.sym} 7290 -180 0 1 {name=R135
value=500
footprint=1206
device=resistor
m=1}
C {res.sym} 6930 -180 0 1 {name=R136
value=500
footprint=1206
device=resistor
m=1}
C {lab_wire.sym} 7180 140 0 1 {name=p487 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 7180 220 0 1 {name=p488 sig_type=std_logic lab=VBIAS}
C {DFF.sym} 9430 680 3 0 {name=x66}
C {DFF.sym} 8600 650 3 0 {name=x67}
C {DFF.sym} 7800 630 3 0 {name=x68}
C {DFF.sym} 7070 630 3 0 {name=x69}
