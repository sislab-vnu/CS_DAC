v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N -2800 -1950 -2710 -1950 {
lab=D7}
N -2800 -1970 -2710 -1970 {
lab=D6}
N -2800 -1990 -2710 -1990 {
lab=D5}
N -2800 -2010 -2710 -2010 {
lab=D4}
N -2800 -2030 -2710 -2030 {
lab=D3}
N -2800 -2050 -2710 -2050 {
lab=D2}
N -2800 -2070 -2710 -2070 {
lab=D1}
N -1810 -2650 -1810 -2560 {
lab=C7}
N -1830 -2650 -1830 -2560 {
lab=C6}
N -1850 -2650 -1850 -2560 {
lab=C5}
N -1870 -2650 -1870 -2560 {
lab=C4}
N -1890 -2650 -1890 -2560 {
lab=C3}
N -1910 -2650 -1910 -2560 {
lab=C2}
N -1930 -2650 -1930 -2560 {
lab=C1}
N -2450 -2080 -2350 -2080 {
lab=D1}
N -2450 -2060 -2350 -2060 {
lab=C1}
N -1910 -2080 -1840 -2080 {
lab=D1}
N -1380 -2080 -1350 -2080 {
lab=D1}
N -910 -2080 -850 -2080 {
lab=D1}
N -380 -2080 -330 -2080 {
lab=D1}
N 150 -2080 190 -2080 {
lab=D1}
N 150 -2080 190 -2080 {
lab=D1}
N 670 -2080 710 -2080 {
lab=D1}
N 670 -2080 710 -2080 {
lab=D1}
N -1900 -2060 -1840 -2060 {
lab=C2}
N -1380 -2060 -1350 -2060 {
lab=C3}
N -900 -2060 -850 -2060 {
lab=C4}
N 160 -2060 190 -2060 {
lab=C6}
N 680 -2060 710 -2060 {
lab=C7}
N -370 -2060 -330 -2060 {
lab=C5}
N -3150 -1950 -3100 -1950 {
lab=X10}
N -3150 -1970 -3100 -1970 {
lab=X9}
N -3150 -1990 -3100 -1990 {
lab=X8}
N -1810 -3010 -1810 -2950 {
lab=X7}
N -1830 -3010 -1830 -2950 {
lab=X6}
N -1850 -3010 -1850 -2950 {
lab=X5}
N 2000 -1660 2000 -1600 {
lab=CLK}
N 2020 -1660 2020 -1600 {
lab=X4}
N 2260 -1660 2260 -1600 {
lab=CLK}
N 2280 -1660 2280 -1600 {
lab=X3}
N 2510 -1660 2510 -1600 {
lab=CLK}
N 2530 -1660 2530 -1600 {
lab=X2}
N 2740 -1660 2740 -1600 {
lab=CLK}
N 2760 -1660 2760 -1600 {
lab=X1}
N 2740 -1840 2800 -1840 {
lab=#net1}
N 2740 -2020 2740 -1840 {
lab=#net1}
N 2800 -2020 2800 -1920 {
lab=#net2}
N 2780 -2020 2780 -2000 {
lab=VBIAS}
N 2780 -2000 2870 -2000 {
lab=VBIAS}
N 2760 -2020 2760 -2000 {
lab=GND}
N 2710 -2000 2760 -2000 {
lab=GND}
N 2570 -1890 2570 -1840 {
lab=#net3}
N 2510 -1840 2550 -1840 {
lab=#net3}
N 2510 -2020 2510 -1840 {
lab=#net3}
N 2550 -1840 2570 -1840 {
lab=#net3}
N 2570 -2020 2570 -1970 {
lab=#net4}
N 2510 -2420 2510 -2320 {
lab=OUT-}
N 2570 -2460 2570 -2320 {
lab=OUT+}
N 2260 -2020 2260 -1840 {
lab=#net5}
N 2260 -1840 2320 -1840 {
lab=#net5}
N 2320 -2020 2320 -1920 {
lab=#net6}
N 2300 -2020 2300 -1990 {
lab=GND}
N 2300 -1990 2350 -1990 {
lab=GND}
N 2280 -2020 2280 -1990 {
lab=VBIAS}
N 2230 -1990 2280 -1990 {
lab=VBIAS}
N 2530 -2020 2530 -1980 {
lab=VBIAS}
N 2440 -1980 2530 -1980 {
lab=VBIAS}
N 2550 -2020 2550 -1980 {
lab=GND}
N 2550 -1980 2620 -1980 {
lab=GND}
N 2260 -2420 2260 -2320 {
lab=OUT-}
N 2320 -2460 2320 -2320 {
lab=OUT+}
N 2000 -2020 2000 -1840 {
lab=#net7}
N 2000 -1840 2060 -1840 {
lab=#net7}
N 2060 -2020 2060 -1920 {
lab=#net8}
N 2020 -2020 2020 -1980 {
lab=VBIAS}
N 1950 -1980 2020 -1980 {
lab=VBIAS}
N 2040 -2020 2040 -1980 {
lab=GND}
N 2040 -1980 2120 -1980 {
lab=GND}
N 2000 -2410 2000 -2320 {
lab=OUT-}
N -2140 -2100 -2060 -2100 {
lab=#net9}
N -2000 -2100 -2000 -2080 {
lab=#net10}
N -2140 -2080 -2000 -2080 {
lab=#net10}
N -2040 -2100 -2040 -2040 {
lab=VBIAS}
N -2020 -2100 -2020 -2040 {
lab=GND}
N -2060 -2500 -2060 -2400 {
lab=OUT+}
N -2000 -2460 -2000 -2400 {
lab=OUT-}
N -1630 -2100 -1560 -2100 {
lab=#net11}
N -1630 -2080 -1500 -2080 {
lab=#net12}
N -1500 -2100 -1500 -2080 {
lab=#net12}
N -1520 -2100 -1520 -2060 {
lab=GND}
N -1540 -2100 -1540 -2040 {
lab=VBIAS}
N -1520 -2060 -1520 -2040 {
lab=GND}
N -1500 -2460 -1500 -2400 {
lab=OUT-}
N -1140 -2100 -1070 -2100 {
lab=#net13}
N -1140 -2080 -1010 -2080 {
lab=#net14}
N -1010 -2100 -1010 -2080 {
lab=#net14}
N -1030 -2100 -1030 -2060 {
lab=GND}
N -1050 -2100 -1050 -2040 {
lab=VBIAS}
N -1030 -2060 -1030 -2040 {
lab=GND}
N -1010 -2460 -1010 -2400 {
lab=OUT-}
N -640 -2100 -570 -2100 {
lab=#net15}
N -640 -2080 -510 -2080 {
lab=#net16}
N -510 -2100 -510 -2080 {
lab=#net16}
N -530 -2100 -530 -2060 {
lab=GND}
N -550 -2100 -550 -2040 {
lab=VBIAS}
N -530 -2060 -530 -2040 {
lab=GND}
N -510 -2460 -510 -2400 {
lab=OUT-}
N -120 -2100 -50 -2100 {
lab=#net17}
N -120 -2080 10 -2080 {
lab=#net18}
N 10 -2100 10 -2080 {
lab=#net18}
N -10 -2100 -10 -2060 {
lab=GND}
N -30 -2100 -30 -2040 {
lab=VBIAS}
N -10 -2060 -10 -2040 {
lab=GND}
N 10 -2460 10 -2400 {
lab=OUT-}
N 400 -2100 470 -2100 {
lab=#net19}
N 400 -2080 530 -2080 {
lab=#net20}
N 530 -2100 530 -2080 {
lab=#net20}
N 510 -2100 510 -2060 {
lab=GND}
N 490 -2100 490 -2040 {
lab=VBIAS}
N 510 -2060 510 -2040 {
lab=GND}
N 530 -2460 530 -2400 {
lab=OUT-}
N 920 -2100 990 -2100 {
lab=#net21}
N 920 -2080 1050 -2080 {
lab=#net22}
N 1050 -2100 1050 -2080 {
lab=#net22}
N 1030 -2100 1030 -2060 {
lab=GND}
N 1010 -2100 1010 -2040 {
lab=VBIAS}
N 1030 -2060 1030 -2040 {
lab=GND}
N 1050 -2460 1050 -2400 {
lab=OUT-}
N 1170 -2080 1210 -2080 {
lab=D1}
N 1170 -2080 1210 -2080 {
lab=D1}
N 1190 -2060 1210 -2060 {
lab=GND}
N 1420 -2100 1490 -2100 {
lab=#net23}
N 1420 -2080 1550 -2080 {
lab=#net24}
N 1550 -2100 1550 -2080 {
lab=#net24}
N 1530 -2100 1530 -2060 {
lab=GND}
N 1510 -2100 1510 -2040 {
lab=VBIAS}
N 1530 -2060 1530 -2040 {
lab=GND}
N 1550 -2460 1550 -2400 {
lab=OUT-}
N -2450 -1480 -2350 -1480 {
lab=D2}
N -2450 -1460 -2350 -1460 {
lab=C1}
N -1910 -1480 -1840 -1480 {
lab=D2}
N -1380 -1480 -1350 -1480 {
lab=D2}
N -910 -1480 -850 -1480 {
lab=D2}
N -380 -1480 -330 -1480 {
lab=D2}
N 150 -1480 190 -1480 {
lab=D2}
N 150 -1480 190 -1480 {
lab=D2}
N 670 -1480 710 -1480 {
lab=D2}
N 670 -1480 710 -1480 {
lab=D2}
N -1900 -1460 -1840 -1460 {
lab=C2}
N -1380 -1460 -1350 -1460 {
lab=C3}
N -900 -1460 -850 -1460 {
lab=C4}
N 160 -1460 190 -1460 {
lab=C6}
N 680 -1460 710 -1460 {
lab=C7}
N -370 -1460 -330 -1460 {
lab=C5}
N -2140 -1500 -2060 -1500 {
lab=#net25}
N -2000 -1500 -2000 -1480 {
lab=#net26}
N -2140 -1480 -2000 -1480 {
lab=#net26}
N -2040 -1500 -2040 -1440 {
lab=VBIAS}
N -2020 -1500 -2020 -1440 {
lab=GND}
N -2060 -1900 -2060 -1800 {
lab=OUT+}
N -2000 -1860 -2000 -1800 {
lab=OUT-}
N -1630 -1500 -1560 -1500 {
lab=#net27}
N -1630 -1480 -1500 -1480 {
lab=#net28}
N -1500 -1500 -1500 -1480 {
lab=#net28}
N -1520 -1500 -1520 -1460 {
lab=GND}
N -1540 -1500 -1540 -1440 {
lab=VBIAS}
N -1520 -1460 -1520 -1440 {
lab=GND}
N -1500 -1860 -1500 -1800 {
lab=OUT-}
N -1140 -1500 -1070 -1500 {
lab=#net29}
N -1140 -1480 -1010 -1480 {
lab=#net30}
N -1010 -1500 -1010 -1480 {
lab=#net30}
N -1030 -1500 -1030 -1460 {
lab=GND}
N -1050 -1500 -1050 -1440 {
lab=VBIAS}
N -1030 -1460 -1030 -1440 {
lab=GND}
N -1010 -1860 -1010 -1800 {
lab=OUT-}
N -640 -1500 -570 -1500 {
lab=#net31}
N -640 -1480 -510 -1480 {
lab=#net32}
N -510 -1500 -510 -1480 {
lab=#net32}
N -530 -1500 -530 -1460 {
lab=GND}
N -550 -1500 -550 -1440 {
lab=VBIAS}
N -530 -1460 -530 -1440 {
lab=GND}
N -510 -1860 -510 -1800 {
lab=OUT-}
N -120 -1500 -50 -1500 {
lab=#net33}
N -120 -1480 10 -1480 {
lab=#net34}
N 10 -1500 10 -1480 {
lab=#net34}
N -10 -1500 -10 -1460 {
lab=GND}
N -30 -1500 -30 -1440 {
lab=VBIAS}
N -10 -1460 -10 -1440 {
lab=GND}
N 10 -1860 10 -1800 {
lab=OUT-}
N 400 -1500 470 -1500 {
lab=#net35}
N 400 -1480 530 -1480 {
lab=#net36}
N 530 -1500 530 -1480 {
lab=#net36}
N 510 -1500 510 -1460 {
lab=GND}
N 490 -1500 490 -1440 {
lab=VBIAS}
N 510 -1460 510 -1440 {
lab=GND}
N 530 -1860 530 -1800 {
lab=OUT-}
N 920 -1500 990 -1500 {
lab=#net37}
N 920 -1480 1050 -1480 {
lab=#net38}
N 1050 -1500 1050 -1480 {
lab=#net38}
N 1030 -1500 1030 -1460 {
lab=GND}
N 1010 -1500 1010 -1440 {
lab=VBIAS}
N 1030 -1460 1030 -1440 {
lab=GND}
N 1050 -1860 1050 -1800 {
lab=OUT-}
N 1170 -1480 1210 -1480 {
lab=D2}
N 1170 -1480 1210 -1480 {
lab=D2}
N 1190 -1460 1210 -1460 {
lab=GND}
N 1420 -1500 1490 -1500 {
lab=#net39}
N 1420 -1480 1550 -1480 {
lab=#net40}
N 1550 -1500 1550 -1480 {
lab=#net40}
N 1530 -1500 1530 -1460 {
lab=GND}
N 1510 -1500 1510 -1440 {
lab=VBIAS}
N 1530 -1460 1530 -1440 {
lab=GND}
N 1550 -1860 1550 -1800 {
lab=OUT-}
N -2450 -870 -2350 -870 {
lab=D3}
N -2450 -850 -2350 -850 {
lab=C1}
N -1910 -870 -1840 -870 {
lab=D3}
N -1380 -870 -1350 -870 {
lab=D3}
N -910 -870 -850 -870 {
lab=D3}
N -380 -870 -330 -870 {
lab=D3}
N 150 -870 190 -870 {
lab=D3}
N 150 -870 190 -870 {
lab=D3}
N 670 -870 710 -870 {
lab=D3}
N 670 -870 710 -870 {
lab=D3}
N -1900 -850 -1840 -850 {
lab=C2}
N -1380 -850 -1350 -850 {
lab=C3}
N -900 -850 -850 -850 {
lab=C4}
N 160 -850 190 -850 {
lab=C6}
N 680 -850 710 -850 {
lab=C7}
N -370 -850 -330 -850 {
lab=C5}
N -2140 -890 -2060 -890 {
lab=#net41}
N -2000 -890 -2000 -870 {
lab=#net42}
N -2140 -870 -2000 -870 {
lab=#net42}
N -2040 -890 -2040 -830 {
lab=VBIAS}
N -2020 -890 -2020 -830 {
lab=GND}
N -2060 -1290 -2060 -1190 {
lab=OUT+}
N -2000 -1250 -2000 -1190 {
lab=OUT-}
N -1630 -890 -1560 -890 {
lab=#net43}
N -1630 -870 -1500 -870 {
lab=#net44}
N -1500 -890 -1500 -870 {
lab=#net44}
N -1520 -890 -1520 -850 {
lab=GND}
N -1540 -890 -1540 -830 {
lab=VBIAS}
N -1520 -850 -1520 -830 {
lab=GND}
N -1500 -1250 -1500 -1190 {
lab=OUT-}
N -1140 -890 -1070 -890 {
lab=#net45}
N -1140 -870 -1010 -870 {
lab=#net46}
N -1010 -890 -1010 -870 {
lab=#net46}
N -1030 -890 -1030 -850 {
lab=GND}
N -1050 -890 -1050 -830 {
lab=VBIAS}
N -1030 -850 -1030 -830 {
lab=GND}
N -1010 -1250 -1010 -1190 {
lab=OUT-}
N -640 -890 -570 -890 {
lab=#net47}
N -640 -870 -510 -870 {
lab=#net48}
N -510 -890 -510 -870 {
lab=#net48}
N -530 -890 -530 -850 {
lab=GND}
N -550 -890 -550 -830 {
lab=VBIAS}
N -530 -850 -530 -830 {
lab=GND}
N -510 -1250 -510 -1190 {
lab=OUT-}
N -120 -890 -50 -890 {
lab=#net49}
N -120 -870 10 -870 {
lab=#net50}
N 10 -890 10 -870 {
lab=#net50}
N -10 -890 -10 -850 {
lab=GND}
N -30 -890 -30 -830 {
lab=VBIAS}
N -10 -850 -10 -830 {
lab=GND}
N 10 -1250 10 -1190 {
lab=OUT-}
N 400 -890 470 -890 {
lab=#net51}
N 400 -870 530 -870 {
lab=#net52}
N 530 -890 530 -870 {
lab=#net52}
N 510 -890 510 -850 {
lab=GND}
N 490 -890 490 -830 {
lab=VBIAS}
N 510 -850 510 -830 {
lab=GND}
N 530 -1250 530 -1190 {
lab=OUT-}
N 920 -890 990 -890 {
lab=#net53}
N 920 -870 1050 -870 {
lab=#net54}
N 1050 -890 1050 -870 {
lab=#net54}
N 1030 -890 1030 -850 {
lab=GND}
N 1010 -890 1010 -830 {
lab=VBIAS}
N 1030 -850 1030 -830 {
lab=GND}
N 1050 -1250 1050 -1190 {
lab=OUT-}
N 1170 -870 1210 -870 {
lab=D3}
N 1170 -870 1210 -870 {
lab=D3}
N 1190 -850 1210 -850 {
lab=GND}
N 1420 -890 1490 -890 {
lab=#net55}
N 1420 -870 1550 -870 {
lab=#net56}
N 1550 -890 1550 -870 {
lab=#net56}
N 1530 -890 1530 -850 {
lab=GND}
N 1510 -890 1510 -830 {
lab=VBIAS}
N 1530 -850 1530 -830 {
lab=GND}
N 1550 -1250 1550 -1190 {
lab=OUT-}
N -2450 -250 -2350 -250 {
lab=D4}
N -2450 -230 -2350 -230 {
lab=C1}
N -1910 -250 -1840 -250 {
lab=D4}
N -1380 -250 -1350 -250 {
lab=D4}
N -910 -250 -850 -250 {
lab=D4}
N -380 -250 -330 -250 {
lab=D4}
N 150 -250 190 -250 {
lab=D4}
N 150 -250 190 -250 {
lab=D4}
N 670 -250 710 -250 {
lab=D4}
N 670 -250 710 -250 {
lab=D4}
N -1900 -230 -1840 -230 {
lab=C2}
N -1380 -230 -1350 -230 {
lab=C3}
N -900 -230 -850 -230 {
lab=C4}
N 160 -230 190 -230 {
lab=C6}
N 680 -230 710 -230 {
lab=C7}
N -370 -230 -330 -230 {
lab=C5}
N -2140 -270 -2060 -270 {
lab=#net57}
N -2000 -270 -2000 -250 {
lab=#net58}
N -2140 -250 -2000 -250 {
lab=#net58}
N -2040 -270 -2040 -210 {
lab=VBIAS}
N -2020 -270 -2020 -210 {
lab=GND}
N -2060 -670 -2060 -570 {
lab=OUT+}
N -2000 -630 -2000 -570 {
lab=OUT-}
N -1630 -270 -1560 -270 {
lab=#net59}
N -1630 -250 -1500 -250 {
lab=#net60}
N -1500 -270 -1500 -250 {
lab=#net60}
N -1520 -270 -1520 -230 {
lab=GND}
N -1540 -270 -1540 -210 {
lab=VBIAS}
N -1520 -230 -1520 -210 {
lab=GND}
N -1500 -630 -1500 -570 {
lab=OUT-}
N -1140 -270 -1070 -270 {
lab=#net61}
N -1140 -250 -1010 -250 {
lab=#net62}
N -1010 -270 -1010 -250 {
lab=#net62}
N -1030 -270 -1030 -230 {
lab=GND}
N -1050 -270 -1050 -210 {
lab=VBIAS}
N -1030 -230 -1030 -210 {
lab=GND}
N -1010 -630 -1010 -570 {
lab=OUT-}
N -640 -270 -570 -270 {
lab=#net63}
N -640 -250 -510 -250 {
lab=#net64}
N -510 -270 -510 -250 {
lab=#net64}
N -530 -270 -530 -230 {
lab=GND}
N -550 -270 -550 -210 {
lab=VBIAS}
N -530 -230 -530 -210 {
lab=GND}
N -510 -630 -510 -570 {
lab=OUT-}
N -120 -270 -50 -270 {
lab=#net65}
N -120 -250 10 -250 {
lab=#net66}
N 10 -270 10 -250 {
lab=#net66}
N -10 -270 -10 -230 {
lab=GND}
N -30 -270 -30 -210 {
lab=VBIAS}
N -10 -230 -10 -210 {
lab=GND}
N 10 -630 10 -570 {
lab=OUT-}
N 400 -270 470 -270 {
lab=#net67}
N 400 -250 530 -250 {
lab=#net68}
N 530 -270 530 -250 {
lab=#net68}
N 510 -270 510 -230 {
lab=GND}
N 490 -270 490 -210 {
lab=VBIAS}
N 510 -230 510 -210 {
lab=GND}
N 530 -630 530 -570 {
lab=OUT-}
N 920 -270 990 -270 {
lab=#net69}
N 920 -250 1050 -250 {
lab=#net70}
N 1050 -270 1050 -250 {
lab=#net70}
N 1030 -270 1030 -230 {
lab=GND}
N 1010 -270 1010 -210 {
lab=VBIAS}
N 1030 -230 1030 -210 {
lab=GND}
N 1050 -630 1050 -570 {
lab=OUT-}
N 1170 -250 1210 -250 {
lab=D4}
N 1170 -250 1210 -250 {
lab=D4}
N 1190 -230 1210 -230 {
lab=GND}
N 1420 -270 1490 -270 {
lab=#net71}
N 1420 -250 1550 -250 {
lab=#net72}
N 1550 -270 1550 -250 {
lab=#net72}
N 1530 -270 1530 -230 {
lab=GND}
N 1510 -270 1510 -210 {
lab=VBIAS}
N 1530 -230 1530 -210 {
lab=GND}
N 1550 -630 1550 -570 {
lab=OUT-}
N -2450 310 -2350 310 {
lab=D5}
N -2450 330 -2350 330 {
lab=C1}
N -1910 310 -1840 310 {
lab=D5}
N -1380 310 -1350 310 {
lab=D5}
N -910 310 -850 310 {
lab=D5}
N -380 310 -330 310 {
lab=D5}
N 150 310 190 310 {
lab=D5}
N 150 310 190 310 {
lab=D5}
N 670 310 710 310 {
lab=D5}
N 670 310 710 310 {
lab=D5}
N -1900 330 -1840 330 {
lab=C2}
N -1380 330 -1350 330 {
lab=C3}
N -900 330 -850 330 {
lab=C4}
N 160 330 190 330 {
lab=C6}
N 680 330 710 330 {
lab=C7}
N -370 330 -330 330 {
lab=C5}
N -2140 290 -2060 290 {
lab=#net73}
N -2000 290 -2000 310 {
lab=#net74}
N -2140 310 -2000 310 {
lab=#net74}
N -2040 290 -2040 350 {
lab=VBIAS}
N -2020 290 -2020 350 {
lab=GND}
N -2060 -110 -2060 -10 {
lab=OUT+}
N -2000 -70 -2000 -10 {
lab=OUT-}
N -1630 290 -1560 290 {
lab=#net75}
N -1630 310 -1500 310 {
lab=#net76}
N -1500 290 -1500 310 {
lab=#net76}
N -1520 290 -1520 330 {
lab=GND}
N -1540 290 -1540 350 {
lab=VBIAS}
N -1520 330 -1520 350 {
lab=GND}
N -1500 -70 -1500 -10 {
lab=OUT-}
N -1140 290 -1070 290 {
lab=#net77}
N -1140 310 -1010 310 {
lab=#net78}
N -1010 290 -1010 310 {
lab=#net78}
N -1030 290 -1030 330 {
lab=GND}
N -1050 290 -1050 350 {
lab=VBIAS}
N -1030 330 -1030 350 {
lab=GND}
N -1010 -70 -1010 -10 {
lab=OUT-}
N -640 290 -570 290 {
lab=#net79}
N -640 310 -510 310 {
lab=#net80}
N -510 290 -510 310 {
lab=#net80}
N -530 290 -530 330 {
lab=GND}
N -550 290 -550 350 {
lab=VBIAS}
N -530 330 -530 350 {
lab=GND}
N -510 -70 -510 -10 {
lab=OUT-}
N -120 290 -50 290 {
lab=#net81}
N -120 310 10 310 {
lab=#net82}
N 10 290 10 310 {
lab=#net82}
N -10 290 -10 330 {
lab=GND}
N -30 290 -30 350 {
lab=VBIAS}
N -10 330 -10 350 {
lab=GND}
N 400 290 470 290 {
lab=#net83}
N 400 310 530 310 {
lab=#net84}
N 530 290 530 310 {
lab=#net84}
N 510 290 510 330 {
lab=GND}
N 490 290 490 350 {
lab=VBIAS}
N 510 330 510 350 {
lab=GND}
N 530 -70 530 -10 {
lab=OUT-}
N 920 290 990 290 {
lab=#net85}
N 920 310 1050 310 {
lab=#net86}
N 1050 290 1050 310 {
lab=#net86}
N 1030 290 1030 330 {
lab=GND}
N 1010 290 1010 350 {
lab=VBIAS}
N 1030 330 1030 350 {
lab=GND}
N 1050 -70 1050 -10 {
lab=OUT-}
N 1170 310 1210 310 {
lab=D5}
N 1170 310 1210 310 {
lab=D5}
N 1190 330 1210 330 {
lab=GND}
N 1420 290 1490 290 {
lab=#net87}
N 1420 310 1550 310 {
lab=#net88}
N 1550 290 1550 310 {
lab=#net88}
N 1530 290 1530 330 {
lab=GND}
N 1510 290 1510 350 {
lab=VBIAS}
N 1530 330 1530 350 {
lab=GND}
N 1550 -70 1550 -10 {
lab=OUT-}
N -2450 850 -2350 850 {
lab=D6}
N -2450 870 -2350 870 {
lab=C1}
N -910 850 -850 850 {
lab=D6}
N -380 850 -330 850 {
lab=D6}
N 150 850 190 850 {
lab=D6}
N 150 850 190 850 {
lab=D6}
N 670 850 710 850 {
lab=D6}
N 670 850 710 850 {
lab=D6}
N -1900 870 -1840 870 {
lab=C2}
N -1380 870 -1350 870 {
lab=C3}
N -900 870 -850 870 {
lab=C4}
N 160 870 190 870 {
lab=C6}
N 680 870 710 870 {
lab=C7}
N -370 870 -330 870 {
lab=C5}
N -2140 830 -2060 830 {
lab=#net89}
N -2000 830 -2000 850 {
lab=#net90}
N -2140 850 -2000 850 {
lab=#net90}
N -2040 830 -2040 890 {
lab=VBIAS}
N -2020 830 -2020 890 {
lab=GND}
N -2060 430 -2060 530 {
lab=OUT+}
N -2000 470 -2000 530 {
lab=OUT-}
N -1630 830 -1560 830 {
lab=#net91}
N -1630 850 -1500 850 {
lab=#net92}
N -1500 830 -1500 850 {
lab=#net92}
N -1520 830 -1520 870 {
lab=GND}
N -1540 830 -1540 890 {
lab=VBIAS}
N -1520 870 -1520 890 {
lab=GND}
N -1500 470 -1500 530 {
lab=OUT-}
N -1140 830 -1070 830 {
lab=#net93}
N -1140 850 -1010 850 {
lab=#net94}
N -1010 830 -1010 850 {
lab=#net94}
N -1030 830 -1030 870 {
lab=GND}
N -1050 830 -1050 890 {
lab=VBIAS}
N -1030 870 -1030 890 {
lab=GND}
N -1010 470 -1010 530 {
lab=OUT-}
N -640 830 -570 830 {
lab=#net95}
N -640 850 -510 850 {
lab=#net96}
N -510 830 -510 850 {
lab=#net96}
N -530 830 -530 870 {
lab=GND}
N -550 830 -550 890 {
lab=VBIAS}
N -530 870 -530 890 {
lab=GND}
N -510 470 -510 530 {
lab=OUT-}
N -120 830 -50 830 {
lab=#net97}
N -120 850 10 850 {
lab=#net98}
N 10 830 10 850 {
lab=#net98}
N -10 830 -10 870 {
lab=GND}
N -30 830 -30 890 {
lab=VBIAS}
N -10 870 -10 890 {
lab=GND}
N 10 470 10 530 {
lab=OUT-}
N 400 830 470 830 {
lab=#net99}
N 400 850 530 850 {
lab=#net100}
N 530 830 530 850 {
lab=#net100}
N 510 830 510 870 {
lab=GND}
N 490 830 490 890 {
lab=VBIAS}
N 510 870 510 890 {
lab=GND}
N 530 470 530 530 {
lab=OUT-}
N 920 830 990 830 {
lab=#net101}
N 920 850 1050 850 {
lab=#net102}
N 1050 830 1050 850 {
lab=#net102}
N 1030 830 1030 870 {
lab=GND}
N 1010 830 1010 890 {
lab=VBIAS}
N 1030 870 1030 890 {
lab=GND}
N 1050 470 1050 530 {
lab=OUT-}
N 1170 850 1210 850 {
lab=D6}
N 1170 850 1210 850 {
lab=D6}
N 1190 870 1210 870 {
lab=GND}
N 1420 830 1490 830 {
lab=#net103}
N 1420 850 1550 850 {
lab=#net104}
N 1550 830 1550 850 {
lab=#net104}
N 1530 830 1530 870 {
lab=GND}
N 1510 830 1510 890 {
lab=VBIAS}
N 1530 870 1530 890 {
lab=GND}
N 1550 470 1550 530 {
lab=OUT-}
N -2450 1430 -2350 1430 {
lab=D7}
N -2450 1450 -2350 1450 {
lab=C1}
N -1910 1430 -1840 1430 {
lab=D7}
N -1380 1430 -1350 1430 {
lab=D7}
N -910 1430 -850 1430 {
lab=D7}
N -380 1430 -330 1430 {
lab=D7}
N 150 1430 190 1430 {
lab=D7}
N 150 1430 190 1430 {
lab=D7}
N 670 1430 710 1430 {
lab=D7}
N 670 1430 710 1430 {
lab=D7}
N -1900 1450 -1840 1450 {
lab=C2}
N -1380 1450 -1350 1450 {
lab=C3}
N -900 1450 -850 1450 {
lab=C4}
N 160 1450 190 1450 {
lab=C6}
N 680 1450 710 1450 {
lab=C7}
N -370 1450 -330 1450 {
lab=C5}
N -2140 1410 -2060 1410 {
lab=#net105}
N -2000 1410 -2000 1430 {
lab=#net106}
N -2140 1430 -2000 1430 {
lab=#net106}
N -2040 1410 -2040 1470 {
lab=VBIAS}
N -2020 1410 -2020 1470 {
lab=GND}
N -2060 1010 -2060 1110 {
lab=OUT+}
N -2000 1050 -2000 1110 {
lab=OUT-}
N -1630 1410 -1560 1410 {
lab=#net107}
N -1630 1430 -1500 1430 {
lab=#net108}
N -1500 1410 -1500 1430 {
lab=#net108}
N -1520 1410 -1520 1450 {
lab=GND}
N -1540 1410 -1540 1470 {
lab=VBIAS}
N -1520 1450 -1520 1470 {
lab=GND}
N -1500 1050 -1500 1110 {
lab=OUT-}
N -1140 1410 -1070 1410 {
lab=#net109}
N -1140 1430 -1010 1430 {
lab=#net110}
N -1010 1410 -1010 1430 {
lab=#net110}
N -1030 1410 -1030 1450 {
lab=GND}
N -1050 1410 -1050 1470 {
lab=VBIAS}
N -1030 1450 -1030 1470 {
lab=GND}
N -1010 1050 -1010 1110 {
lab=OUT-}
N -640 1410 -570 1410 {
lab=#net111}
N -640 1430 -510 1430 {
lab=#net112}
N -510 1410 -510 1430 {
lab=#net112}
N -530 1410 -530 1450 {
lab=GND}
N -550 1410 -550 1470 {
lab=VBIAS}
N -530 1450 -530 1470 {
lab=GND}
N -510 1050 -510 1110 {
lab=OUT-}
N -120 1410 -50 1410 {
lab=#net113}
N -120 1430 10 1430 {
lab=#net114}
N 10 1410 10 1430 {
lab=#net114}
N -10 1410 -10 1450 {
lab=GND}
N -30 1410 -30 1470 {
lab=VBIAS}
N -10 1450 -10 1470 {
lab=GND}
N 10 1050 10 1110 {
lab=OUT-}
N 400 1410 470 1410 {
lab=#net115}
N 400 1430 530 1430 {
lab=#net116}
N 530 1410 530 1430 {
lab=#net116}
N 510 1410 510 1450 {
lab=GND}
N 490 1410 490 1470 {
lab=VBIAS}
N 510 1450 510 1470 {
lab=GND}
N 530 1050 530 1110 {
lab=OUT-}
N 920 1410 990 1410 {
lab=#net117}
N 920 1430 1050 1430 {
lab=#net118}
N 1050 1410 1050 1430 {
lab=#net118}
N 1030 1410 1030 1450 {
lab=GND}
N 1010 1410 1010 1470 {
lab=VBIAS}
N 1030 1450 1030 1470 {
lab=GND}
N 1050 1050 1050 1110 {
lab=OUT-}
N 1170 1430 1210 1430 {
lab=D7}
N 1170 1430 1210 1430 {
lab=D7}
N 1190 1450 1210 1450 {
lab=GND}
N 1420 1410 1490 1410 {
lab=#net119}
N 1420 1430 1550 1430 {
lab=#net120}
N 1550 1410 1550 1430 {
lab=#net120}
N 1530 1410 1530 1450 {
lab=GND}
N 1510 1410 1510 1470 {
lab=VBIAS}
N 1530 1450 1530 1470 {
lab=GND}
N 1550 1050 1550 1110 {
lab=OUT-}
N -2450 2030 -2350 2030 {
lab=GND}
N -2450 2050 -2350 2050 {
lab=C1}
N -1910 2030 -1840 2030 {
lab=GND}
N -1380 2030 -1350 2030 {
lab=GND}
N -910 2030 -850 2030 {
lab=GND}
N -380 2030 -330 2030 {
lab=GND}
N 150 2030 190 2030 {
lab=GND}
N 670 2030 710 2030 {
lab=GND}
N -1900 2050 -1840 2050 {
lab=C2}
N -1380 2050 -1350 2050 {
lab=C3}
N -900 2050 -850 2050 {
lab=C4}
N 160 2050 190 2050 {
lab=C6}
N 680 2050 710 2050 {
lab=C7}
N -370 2050 -330 2050 {
lab=C5}
N -2140 2010 -2060 2010 {
lab=#net121}
N -2000 2010 -2000 2030 {
lab=#net122}
N -2140 2030 -2000 2030 {
lab=#net122}
N -2040 2010 -2040 2070 {
lab=VBIAS}
N -2020 2010 -2020 2070 {
lab=GND}
N -2060 1610 -2060 1710 {
lab=OUT+}
N -2000 1650 -2000 1710 {
lab=OUT-}
N -1630 2010 -1560 2010 {
lab=#net123}
N -1630 2030 -1500 2030 {
lab=#net124}
N -1500 2010 -1500 2030 {
lab=#net124}
N -1520 2010 -1520 2050 {
lab=GND}
N -1540 2010 -1540 2070 {
lab=VBIAS}
N -1520 2050 -1520 2070 {
lab=GND}
N -1500 1650 -1500 1710 {
lab=OUT-}
N -1140 2010 -1070 2010 {
lab=#net125}
N -1140 2030 -1010 2030 {
lab=#net126}
N -1010 2010 -1010 2030 {
lab=#net126}
N -1030 2010 -1030 2050 {
lab=GND}
N -1050 2010 -1050 2070 {
lab=VBIAS}
N -1030 2050 -1030 2070 {
lab=GND}
N -1010 1650 -1010 1710 {
lab=OUT-}
N -640 2010 -570 2010 {
lab=#net127}
N -640 2030 -510 2030 {
lab=#net128}
N -510 2010 -510 2030 {
lab=#net128}
N -530 2010 -530 2050 {
lab=GND}
N -550 2010 -550 2070 {
lab=VBIAS}
N -530 2050 -530 2070 {
lab=GND}
N -510 1650 -510 1710 {
lab=OUT-}
N -120 2010 -50 2010 {
lab=#net129}
N -120 2030 10 2030 {
lab=#net130}
N 10 2010 10 2030 {
lab=#net130}
N -10 2010 -10 2050 {
lab=GND}
N -30 2010 -30 2070 {
lab=VBIAS}
N -10 2050 -10 2070 {
lab=GND}
N 10 1650 10 1710 {
lab=OUT-}
N 400 2010 470 2010 {
lab=#net131}
N 400 2030 530 2030 {
lab=#net132}
N 530 2010 530 2030 {
lab=#net132}
N 510 2010 510 2050 {
lab=GND}
N 490 2010 490 2070 {
lab=VBIAS}
N 510 2050 510 2070 {
lab=GND}
N 530 1650 530 1710 {
lab=OUT-}
N 920 2010 990 2010 {
lab=#net133}
N 920 2030 1050 2030 {
lab=#net134}
N 1050 2010 1050 2030 {
lab=#net134}
N 1030 2010 1030 2050 {
lab=GND}
N 1010 2010 1010 2070 {
lab=VBIAS}
N 1030 2050 1030 2070 {
lab=GND}
N 1050 1650 1050 1710 {
lab=OUT-}
N -1940 850 -1840 850 {
lab=D6}
N -1450 850 -1350 850 {
lab=D6}
N -1420 2030 -1380 2030 {
lab=GND}
N -400 2030 -380 2030 {
lab=GND}
N 110 2030 150 2030 {
lab=GND}
N 630 2030 670 2030 {
lab=GND}
N -2060 -2500 -1030 -2500 {
lab=OUT+}
N -1030 -2500 1740 -2500 {
lab=OUT+}
N -2000 -2460 1680 -2460 {
lab=OUT-}
N -2000 -1860 1680 -1860 {
lab=OUT-}
N -2060 -1900 -1030 -1900 {
lab=OUT+}
N -1030 -1900 1740 -1900 {
lab=OUT+}
N -2060 -1290 -1030 -1290 {
lab=OUT+}
N -1030 -1290 1740 -1290 {
lab=OUT+}
N -2000 -1250 1680 -1250 {
lab=OUT-}
N -2060 -670 -1030 -670 {
lab=OUT+}
N -1030 -670 1740 -670 {
lab=OUT+}
N -2000 -630 1680 -630 {
lab=OUT-}
N -2060 -110 -1030 -110 {
lab=OUT+}
N -1030 -110 1740 -110 {
lab=OUT+}
N -2000 -70 1680 -70 {
lab=OUT-}
N -2060 430 -1030 430 {
lab=OUT+}
N -1030 430 1740 430 {
lab=OUT+}
N -2000 470 1680 470 {
lab=OUT-}
N -2060 1010 -1030 1010 {
lab=OUT+}
N -1030 1010 1740 1010 {
lab=OUT+}
N -2000 1050 1680 1050 {
lab=OUT-}
N -2060 1610 -1030 1610 {
lab=OUT+}
N -1030 1610 1740 1610 {
lab=OUT+}
N -2000 1650 1680 1650 {
lab=OUT-}
N -1560 -2500 -1560 -2400 {
lab=OUT+}
N -1070 -2500 -1070 -2400 {
lab=OUT+}
N -570 -2500 -570 -2400 {
lab=OUT+}
N -50 -2500 -50 -2400 {
lab=OUT+}
N 470 -2500 470 -2400 {
lab=OUT+}
N 990 -2500 990 -2400 {
lab=OUT+}
N 1490 -2500 1490 -2400 {
lab=OUT+}
N -1560 -1900 -1560 -1800 {
lab=OUT+}
N -1070 -1900 -1070 -1800 {
lab=OUT+}
N -570 -1900 -570 -1800 {
lab=OUT+}
N -50 -1900 -50 -1800 {
lab=OUT+}
N 470 -1900 470 -1800 {
lab=OUT+}
N 990 -1900 990 -1800 {
lab=OUT+}
N 1490 -1900 1490 -1800 {
lab=OUT+}
N -1560 -1290 -1560 -1190 {
lab=OUT+}
N -1070 -1290 -1070 -1190 {
lab=OUT+}
N -50 -1290 -50 -1190 {
lab=OUT+}
N 470 -1290 470 -1190 {
lab=OUT+}
N 990 -1290 990 -1190 {
lab=OUT+}
N 1490 -1280 1490 -1190 {
lab=OUT+}
N 1490 -1290 1490 -1280 {
lab=OUT+}
N 470 -670 470 -570 {
lab=OUT+}
N 990 -670 990 -570 {
lab=OUT+}
N 1490 -670 1490 -570 {
lab=OUT+}
N -50 -670 -50 -570 {
lab=OUT+}
N -570 -670 -570 -570 {
lab=OUT+}
N -1070 -670 -1070 -570 {
lab=OUT+}
N -1560 -670 -1560 -570 {
lab=OUT+}
N -1560 -110 -1560 -10 {
lab=OUT+}
N -1070 -110 -1070 -10 {
lab=OUT+}
N -570 -100 -570 -10 {
lab=OUT+}
N -570 -110 -570 -100 {
lab=OUT+}
N 470 -110 470 -10 {
lab=OUT+}
N 990 -110 990 -10 {
lab=OUT+}
N 1490 -110 1490 -10 {
lab=OUT+}
N 470 430 470 530 {
lab=OUT+}
N 990 430 990 530 {
lab=OUT+}
N 1490 430 1490 530 {
lab=OUT+}
N -1070 430 -1070 530 {
lab=OUT+}
N -570 430 -570 530 {
lab=OUT+}
N -50 430 -50 530 {
lab=OUT+}
N -1560 430 -1560 530 {
lab=OUT+}
N -1560 1010 -1560 1110 {
lab=OUT+}
N -1070 1010 -1070 1110 {
lab=OUT+}
N -570 1010 -570 1110 {
lab=OUT+}
N -50 1010 -50 1110 {
lab=OUT+}
N 470 1010 470 1110 {
lab=OUT+}
N 990 1010 990 1110 {
lab=OUT+}
N 1490 1010 1490 1110 {
lab=OUT+}
N 470 1610 470 1710 {
lab=OUT+}
N 990 1610 990 1710 {
lab=OUT+}
N -570 1610 -570 1710 {
lab=OUT+}
N -50 1610 -50 1710 {
lab=OUT+}
N -1560 1610 -1560 1710 {
lab=OUT+}
N -1070 1610 -1070 1710 {
lab=OUT+}
N 1740 -2640 1740 -2500 {
lab=OUT+}
N 1860 -2640 1860 480 {
lab=OUT-}
N 1680 470 1860 470 {
lab=OUT-}
N 1680 -70 1860 -70 {
lab=OUT-}
N 1680 -630 1860 -630 {
lab=OUT-}
N 1680 -1250 1860 -1250 {
lab=OUT-}
N 1680 -1860 1860 -1860 {
lab=OUT-}
N 1680 -2460 1860 -2460 {
lab=OUT-}
N 1740 -2500 1740 430 {
lab=OUT+}
N 1740 430 1740 1610 {
lab=OUT+}
N 1860 480 1860 1650 {
lab=OUT-}
N 1680 1650 1860 1650 {
lab=OUT-}
N 1680 1050 1860 1050 {
lab=OUT-}
N 2000 -2500 2000 -2410 {
lab=OUT-}
N 2000 -2500 2740 -2500 {
lab=OUT-}
N 2260 -2500 2260 -2420 {
lab=OUT-}
N 2510 -2500 2510 -2420 {
lab=OUT-}
N 2740 -2500 2740 -2320 {
lab=OUT-}
N 2060 -2460 2060 -2320 {
lab=OUT+}
N 2060 -2460 2800 -2460 {
lab=OUT+}
N 2800 -2460 2800 -2320 {
lab=OUT+}
N 1740 -2780 1740 -2700 {
lab=VP}
N 1860 -2780 1860 -2700 {
lab=VP}
N -50 -110 -50 -10 {
lab=OUT+}
N 10 -70 10 -10 {
lab=OUT-}
N -570 -1290 -570 -1190 {
lab=OUT+}
N 1860 -2460 2000 -2500 {
lab=OUT-}
N 1740 -2500 2060 -2460 {
lab=OUT+}
C {Local_encoder.sym} -2290 -2070 0 0 {name=x1}
C {Local_encoder.sym} -1780 -2070 0 0 {name=x2}
C {Local_encoder.sym} -1290 -2070 0 0 {name=x3}
C {Local_encoder.sym} -790 -2070 0 0 {name=x4}
C {Local_encoder.sym} -270 -2070 0 0 {name=x5}
C {Local_encoder.sym} 250 -2070 0 0 {name=x6}
C {Local_encoder.sym} 770 -2070 0 0 {name=x7}
C {vsource.sym} -5870 -1680 0 0 {name=V1 value=3.3 savecurrent=false}
C {gnd.sym} -5870 -1650 0 0 {name=l253 lab=GND}
C {lab_wire.sym} -2710 -1950 2 0 {name=p144 sig_type=std_logic lab=D7}
C {lab_wire.sym} -2710 -1970 2 0 {name=p145 sig_type=std_logic lab=D6}
C {lab_wire.sym} -2710 -1990 2 0 {name=p146 sig_type=std_logic lab=D5}
C {lab_wire.sym} -2710 -2010 2 0 {name=p147 sig_type=std_logic lab=D4}
C {lab_wire.sym} -2710 -2030 2 0 {name=p148 sig_type=std_logic lab=D3}
C {lab_wire.sym} -2710 -2050 2 0 {name=p149 sig_type=std_logic lab=D2}
C {lab_wire.sym} -2710 -2070 2 0 {name=p150 sig_type=std_logic lab=D1}
C {lab_wire.sym} -1930 -2560 2 1 {name=p158 sig_type=std_logic lab=C1}
C {lab_wire.sym} -2350 -2040 3 0 {name=p161 sig_type=std_logic lab=CLK}
C {lab_wire.sym} -2450 -2080 3 1 {name=p162 sig_type=std_logic lab=D1}
C {lab_wire.sym} -1910 -2080 3 1 {name=p163 sig_type=std_logic lab=D1}
C {lab_wire.sym} -1380 -2080 3 1 {name=p164 sig_type=std_logic lab=D1}
C {lab_wire.sym} -910 -2080 3 1 {name=p165 sig_type=std_logic lab=D1}
C {lab_wire.sym} -380 -2080 3 1 {name=p166 sig_type=std_logic lab=D1}
C {lab_wire.sym} 150 -2080 3 1 {name=p167 sig_type=std_logic lab=D1}
C {lab_wire.sym} 670 -2080 3 1 {name=p169 sig_type=std_logic lab=D1}
C {lab_wire.sym} -1910 -2560 2 1 {name=p152 sig_type=std_logic lab=C2}
C {lab_wire.sym} -1890 -2560 2 1 {name=p153 sig_type=std_logic lab=C3}
C {lab_wire.sym} -1870 -2560 2 1 {name=p154 sig_type=std_logic lab=C4}
C {lab_wire.sym} -1850 -2560 2 1 {name=p155 sig_type=std_logic lab=C5}
C {lab_wire.sym} -1830 -2560 2 1 {name=p156 sig_type=std_logic lab=C6}
C {lab_wire.sym} -1810 -2560 2 1 {name=p157 sig_type=std_logic lab=C7}
C {lab_wire.sym} -2450 -2060 2 1 {name=p171 sig_type=std_logic lab=C1}
C {lab_wire.sym} -1900 -2060 2 1 {name=p172 sig_type=std_logic lab=C2}
C {lab_wire.sym} -1380 -2060 2 1 {name=p173 sig_type=std_logic lab=C3}
C {lab_wire.sym} -900 -2060 2 1 {name=p174 sig_type=std_logic lab=C4}
C {lab_wire.sym} -370 -2060 2 1 {name=p175 sig_type=std_logic lab=C5}
C {lab_wire.sym} 160 -2060 2 1 {name=p176 sig_type=std_logic lab=C6}
C {lab_wire.sym} 680 -2060 2 1 {name=p177 sig_type=std_logic lab=C7}
C {lab_wire.sym} -1840 -2040 3 0 {name=p440 sig_type=std_logic lab=CLK}
C {lab_wire.sym} -1350 -2040 3 0 {name=p441 sig_type=std_logic lab=CLK}
C {lab_wire.sym} -850 -2040 3 0 {name=p442 sig_type=std_logic lab=CLK}
C {lab_wire.sym} -330 -2040 3 0 {name=p443 sig_type=std_logic lab=CLK}
C {lab_wire.sym} 190 -2040 3 0 {name=p444 sig_type=std_logic lab=CLK}
C {lab_wire.sym} 710 -2040 3 0 {name=p445 sig_type=std_logic lab=CLK}
C {vsource.sym} -5750 -1680 0 0 {name=V3 value=3.3 savecurrent=false}
C {lab_wire.sym} -5750 -1710 0 0 {name=p449 sig_type=std_logic lab=VP}
C {gnd.sym} -5750 -1650 0 0 {name=l269 lab=GND}
C {vsource.sym} -5810 -1680 0 0 {name=V10 value=1.8 savecurrent=false}
C {lab_wire.sym} -5810 -1710 0 0 {name=p462 sig_type=std_logic lab=VBIAS}
C {gnd.sym} -5810 -1650 0 0 {name=l276 lab=GND}
C {vsource.sym} -5540 -1700 0 0 {name=V2 value="PULSE(0 3.3 0 1n 1n 4n 10n)" savecurrent=false}
C {lab_wire.sym} -5540 -1730 0 0 {name=p160 sig_type=std_logic lab=X1}
C {gnd.sym} -5540 -1670 0 0 {name=l254 lab=GND}
C {vsource.sym} -5320 -1700 0 0 {name=V5 value="PULSE(0 3.3 0 1n 1n 9n 20n)" savecurrent=false}
C {lab_wire.sym} -5320 -1730 0 0 {name=p458 sig_type=std_logic lab=X2}
C {gnd.sym} -5320 -1670 0 0 {name=l272 lab=GND}
C {vsource.sym} -5540 -1590 0 0 {name=V6 value="PULSE(0 3.3 0 1n 1n 19n 40n)" savecurrent=false}
C {lab_wire.sym} -5540 -1620 0 0 {name=p459 sig_type=std_logic lab=X3}
C {gnd.sym} -5540 -1560 0 0 {name=l273 lab=GND}
C {vsource.sym} -5310 -1580 0 0 {name=V7 value="PULSE(0 3.3 0 1n 1n 39n 80n)" savecurrent=false}
C {lab_wire.sym} -5310 -1610 0 0 {name=p460 sig_type=std_logic lab=X4}
C {gnd.sym} -5310 -1550 0 0 {name=l274 lab=GND}
C {vsource.sym} -5540 -1470 0 0 {name=V8 value="PULSE(0 3.3 0 1n 1n 79n 160n)" savecurrent=false}
C {lab_wire.sym} -5540 -1500 0 0 {name=p461 sig_type=std_logic lab=X5}
C {gnd.sym} -5540 -1440 0 0 {name=l275 lab=GND}
C {vsource.sym} -5310 -1470 0 0 {name=V9 value="PULSE(0 3.3 0 1n 1n 159n 320n)" savecurrent=false}
C {lab_wire.sym} -5310 -1500 0 0 {name=p489 sig_type=std_logic lab=X6}
C {gnd.sym} -5310 -1440 0 0 {name=l292 lab=GND}
C {lab_wire.sym} -1810 -3010 0 1 {name=p168 sig_type=std_logic lab=X7}
C {lab_wire.sym} -1830 -3010 0 1 {name=p450 sig_type=std_logic lab=X6}
C {lab_wire.sym} -1850 -3010 0 1 {name=p451 sig_type=std_logic lab=X5}
C {lab_wire.sym} -3150 -1950 0 0 {name=p452 sig_type=std_logic lab=X10}
C {lab_wire.sym} -3150 -1970 0 0 {name=p453 sig_type=std_logic lab=X9}
C {lab_wire.sym} -3150 -1990 0 0 {name=p454 sig_type=std_logic lab=X8}
C {vsource.sym} -5540 -1360 0 0 {name=V11 value="PULSE(0 3.3 0 1n 1n 319n 640n)" savecurrent=false}
C {lab_wire.sym} -5540 -1390 0 0 {name=p490 sig_type=std_logic lab=X7}
C {gnd.sym} -5540 -1330 0 0 {name=l293 lab=GND}
C {vsource.sym} -5310 -1360 0 0 {name=V12 value="PULSE(0 3.3 0 1n 1n 639n 1280n)" savecurrent=false}
C {lab_wire.sym} -5310 -1390 0 0 {name=p491 sig_type=std_logic lab=X8}
C {gnd.sym} -5310 -1330 0 0 {name=l294 lab=GND}
C {vsource.sym} -5540 -1240 0 0 {name=V13 value="PULSE(0 3.3 0 1n 1n 1279n 2560n)" savecurrent=false}
C {lab_wire.sym} -5540 -1270 0 0 {name=p492 sig_type=std_logic lab=X9}
C {gnd.sym} -5540 -1210 0 0 {name=l295 lab=GND}
C {vsource.sym} -5300 -1240 0 0 {name=V14 value="PULSE(0 3.3 0 1n 1n 2559n 5120n)" savecurrent=false}
C {lab_wire.sym} -5300 -1270 0 0 {name=p493 sig_type=std_logic lab=X10}
C {gnd.sym} -5300 -1210 0 0 {name=l296 lab=GND}
C {devices/code_shown.sym} -6210 -2180 0 0 {name=MODELS1 only_toplevel=true
format="tcleval( @value )"
value="
.include $::180MCU_MODELS/design.ngspice
.lib $::180MCU_MODELS/sm141064.ngspice statistical
.lib /home/ducluong/eda/unic-cass/envs/gf180mcu-env/share/pdk/gf180mcuC/libs.tech/ngspice/smbb000149.ngspice statistical
"}
C {devices/code_shown.sym} -6210 -2310 0 0 {name=STDCELL_MODELS only_toplevel=false 
format="tcleval( @value )"
value=".include $::180MCU_STDCELLS/gf180mcu_fd_sc_mcu7t5v0.spice"}
C {thermometter_decoder.sym} -2950 -2010 2 1 {name=x64}
C {thermometter_decoder.sym} -1870 -2800 1 0 {name=x65}
C {lab_wire.sym} -5870 -1710 0 0 {name=p127 sig_type=std_logic lab=vcc}
C {lab_wire.sym} -2350 -2100 0 0 {name=p128 sig_type=std_logic lab=vcc}
C {lab_wire.sym} -1840 -2100 0 0 {name=p129 sig_type=std_logic lab=vcc}
C {lab_wire.sym} -1350 -2100 0 0 {name=p130 sig_type=std_logic lab=vcc}
C {lab_wire.sym} -850 -2100 0 0 {name=p131 sig_type=std_logic lab=vcc}
C {lab_wire.sym} -330 -2100 0 0 {name=p132 sig_type=std_logic lab=vcc}
C {lab_wire.sym} 190 -2100 0 0 {name=p133 sig_type=std_logic lab=vcc}
C {lab_wire.sym} 710 -2100 0 0 {name=p134 sig_type=std_logic lab=vcc}
C {code_shown.sym} -6150 -2070 0 0 {name=NGSPICE only_toplevel=false value="
VVDD VDD 0 dc 3.3
VVSS VSS 0 dc 0
VVPW VPW 0 dc 0 
VVNW VNW 0 dc 3.3
.control
tran 1n 5120n
run
wrdata /home/ducluong/CS_DAC/spice/CS_DAC_10b_statistical3.txt v(OUT+) V(OUT-)
.endc
"}
C {lab_wire.sym} 2530 -1600 0 1 {name=p472 sig_type=std_logic lab=X2
}
C {lab_wire.sym} 2740 -1600 0 0 {name=p473 sig_type=std_logic lab=CLK
}
C {lab_wire.sym} 2510 -1600 0 0 {name=p474 sig_type=std_logic lab=CLK
}
C {lab_wire.sym} 2260 -1600 0 0 {name=p475 sig_type=std_logic lab=CLK
}
C {lab_wire.sym} 2000 -1600 0 0 {name=p483 sig_type=std_logic lab=CLK
}
C {lab_wire.sym} 2020 -1600 0 1 {name=p484 sig_type=std_logic lab=X4
}
C {gnd.sym} 2120 -1980 0 1 {name=l297 lab=GND}
C {lab_wire.sym} 2760 -1600 0 1 {name=p485 sig_type=std_logic lab=X1
}
C {lab_wire.sym} 2280 -1600 0 1 {name=p486 sig_type=std_logic lab=X3
}
C {gf180mcuc-stdcells/dffq_2.sym} 2010 -1750 3 0 {name=x66 VDD=VDD VNW=VNW VPW=VPW VSS=VSS prefix=gf180mcu_fd_sc_mcu7t5v0__ }
C {gf180mcuc-stdcells/inv_2.sym} 2060 -1880 3 0 {name=x67 VDD=VDD VNW=VNW VPW=VPW VSS=VSS prefix=gf180mcu_fd_sc_mcu7t5v0__ }
C {gf180mcuc-stdcells/dffq_2.sym} 2270 -1750 3 0 {name=x68 VDD=VDD VNW=VNW VPW=VPW VSS=VSS prefix=gf180mcu_fd_sc_mcu7t5v0__ }
C {gf180mcuc-stdcells/inv_2.sym} 2320 -1880 3 0 {name=x69 VDD=VDD VNW=VNW VPW=VPW VSS=VSS prefix=gf180mcu_fd_sc_mcu7t5v0__ }
C {gf180mcuc-stdcells/dffq_2.sym} 2520 -1750 3 0 {name=x70 VDD=VDD VNW=VNW VPW=VPW VSS=VSS prefix=gf180mcu_fd_sc_mcu7t5v0__ }
C {gf180mcuc-stdcells/inv_2.sym} 2570 -1930 3 0 {name=x71 VDD=VDD VNW=VNW VPW=VPW VSS=VSS prefix=gf180mcu_fd_sc_mcu7t5v0__ }
C {gf180mcuc-stdcells/dffq_2.sym} 2750 -1750 3 0 {name=x72 VDD=VDD VNW=VNW VPW=VPW VSS=VSS prefix=gf180mcu_fd_sc_mcu7t5v0__ }
C {gf180mcuc-stdcells/inv_2.sym} 2800 -1880 3 0 {name=x73 VDD=VDD VNW=VNW VPW=VPW VSS=VSS prefix=gf180mcu_fd_sc_mcu7t5v0__ }
C {vsource.sym} -5220 -1770 0 0 {name=V15 value="PULSE(0 3.3 2n 1n 1n 4n 10n)" savecurrent=false}
C {gnd.sym} -5220 -1740 0 0 {name=l288 lab=GND}
C {lab_wire.sym} -5220 -1800 0 0 {name=p136 sig_type=std_logic lab=CLK}
C {lab_wire.sym} 2870 -2000 0 1 {name=p137 sig_type=std_logic lab=VBIAS}
C {gnd.sym} 2710 -2000 0 1 {name=l270 lab=GND}
C {CS_Switch_1x.sym} 2770 -2170 1 1 {name=x74}
C {CS_Switch_2x.sym} 2540 -2170 3 0 {name=x75}
C {lab_wire.sym} 2440 -1980 0 0 {name=p138 sig_type=std_logic lab=VBIAS}
C {gnd.sym} 2620 -1980 0 1 {name=l271 lab=GND}
C {CS_Switch_4x.sym} 2290 -2170 3 0 {name=x76}
C {gnd.sym} 2350 -1990 0 1 {name=l277 lab=GND}
C {lab_wire.sym} 2230 -1990 0 0 {name=p139 sig_type=std_logic lab=VBIAS}
C {CS_Switch_8x.sym} 2030 -2170 3 0 {name=x77}
C {lab_wire.sym} 1950 -1980 0 0 {name=p140 sig_type=std_logic lab=VBIAS}
C {CS_Switch_16x.sym} -2030 -2250 3 0 {name=x78}
C {gnd.sym} -2020 -2040 0 0 {name=l27 lab=GND}
C {lab_wire.sym} -2040 -2040 0 0 {name=p42 sig_type=std_logic lab=VBIAS}
C {CS_Switch_16x.sym} -1530 -2250 3 0 {name=x79}
C {gnd.sym} -1520 -2040 0 0 {name=l1 lab=GND}
C {lab_wire.sym} -1540 -2040 0 0 {name=p1 sig_type=std_logic lab=VBIAS}
C {CS_Switch_16x.sym} -1040 -2250 3 0 {name=x80}
C {gnd.sym} -1030 -2040 0 0 {name=l2 lab=GND}
C {lab_wire.sym} -1050 -2040 0 0 {name=p2 sig_type=std_logic lab=VBIAS}
C {CS_Switch_16x.sym} -540 -2250 3 0 {name=x81}
C {gnd.sym} -530 -2040 0 0 {name=l3 lab=GND}
C {lab_wire.sym} -550 -2040 0 0 {name=p3 sig_type=std_logic lab=VBIAS}
C {CS_Switch_16x.sym} -20 -2250 3 0 {name=x82}
C {gnd.sym} -10 -2040 0 0 {name=l4 lab=GND}
C {lab_wire.sym} -30 -2040 0 0 {name=p4 sig_type=std_logic lab=VBIAS}
C {CS_Switch_16x.sym} 500 -2250 3 0 {name=x83}
C {gnd.sym} 510 -2040 0 0 {name=l5 lab=GND}
C {lab_wire.sym} 490 -2040 0 0 {name=p5 sig_type=std_logic lab=VBIAS}
C {CS_Switch_16x.sym} 1020 -2250 3 0 {name=x84}
C {gnd.sym} 1030 -2040 0 0 {name=l6 lab=GND}
C {lab_wire.sym} 1010 -2040 0 0 {name=p6 sig_type=std_logic lab=VBIAS}
C {Local_encoder.sym} 1270 -2070 0 0 {name=x85}
C {lab_wire.sym} 1170 -2080 3 1 {name=p7 sig_type=std_logic lab=D1}
C {gnd.sym} 1190 -2060 1 0 {name=l7 lab=GND}
C {lab_wire.sym} 1210 -2040 3 0 {name=p8 sig_type=std_logic lab=CLK}
C {lab_wire.sym} 1210 -2100 0 0 {name=p9 sig_type=std_logic lab=vcc}
C {CS_Switch_16x.sym} 1520 -2250 3 0 {name=x86}
C {gnd.sym} 1530 -2040 0 0 {name=l8 lab=GND}
C {lab_wire.sym} 1510 -2040 0 0 {name=p10 sig_type=std_logic lab=VBIAS}
C {Local_encoder.sym} -2290 -1470 0 0 {name=x8}
C {Local_encoder.sym} -1780 -1470 0 0 {name=x9}
C {Local_encoder.sym} -1290 -1470 0 0 {name=x10}
C {Local_encoder.sym} -790 -1470 0 0 {name=x11}
C {Local_encoder.sym} -270 -1470 0 0 {name=x12}
C {Local_encoder.sym} 250 -1470 0 0 {name=x13}
C {Local_encoder.sym} 770 -1470 0 0 {name=x14}
C {lab_wire.sym} -2350 -1440 3 0 {name=p11 sig_type=std_logic lab=CLK}
C {lab_wire.sym} -2450 -1480 3 1 {name=p12 sig_type=std_logic lab=D2}
C {lab_wire.sym} -1910 -1480 3 1 {name=p13 sig_type=std_logic lab=D2}
C {lab_wire.sym} -1380 -1480 3 1 {name=p14 sig_type=std_logic lab=D2}
C {lab_wire.sym} -910 -1480 3 1 {name=p15 sig_type=std_logic lab=D2}
C {lab_wire.sym} -380 -1480 3 1 {name=p16 sig_type=std_logic lab=D2}
C {lab_wire.sym} 150 -1480 3 1 {name=p17 sig_type=std_logic lab=D2}
C {lab_wire.sym} 670 -1480 3 1 {name=p18 sig_type=std_logic lab=D2}
C {lab_wire.sym} -2450 -1460 2 1 {name=p19 sig_type=std_logic lab=C1}
C {lab_wire.sym} -1900 -1460 2 1 {name=p20 sig_type=std_logic lab=C2}
C {lab_wire.sym} -1380 -1460 2 1 {name=p21 sig_type=std_logic lab=C3}
C {lab_wire.sym} -900 -1460 2 1 {name=p22 sig_type=std_logic lab=C4}
C {lab_wire.sym} -370 -1460 2 1 {name=p23 sig_type=std_logic lab=C5}
C {lab_wire.sym} 160 -1460 2 1 {name=p24 sig_type=std_logic lab=C6}
C {lab_wire.sym} 680 -1460 2 1 {name=p25 sig_type=std_logic lab=C7}
C {lab_wire.sym} -1840 -1440 3 0 {name=p26 sig_type=std_logic lab=CLK}
C {lab_wire.sym} -1350 -1440 3 0 {name=p27 sig_type=std_logic lab=CLK}
C {lab_wire.sym} -850 -1440 3 0 {name=p28 sig_type=std_logic lab=CLK}
C {lab_wire.sym} -330 -1440 3 0 {name=p29 sig_type=std_logic lab=CLK}
C {lab_wire.sym} 190 -1440 3 0 {name=p30 sig_type=std_logic lab=CLK}
C {lab_wire.sym} 710 -1440 3 0 {name=p31 sig_type=std_logic lab=CLK}
C {lab_wire.sym} -2350 -1500 0 0 {name=p32 sig_type=std_logic lab=D1}
C {lab_wire.sym} -1840 -1500 0 0 {name=p33 sig_type=std_logic lab=D1}
C {lab_wire.sym} -1350 -1500 0 0 {name=p34 sig_type=std_logic lab=D1}
C {lab_wire.sym} -850 -1500 0 0 {name=p35 sig_type=std_logic lab=D1}
C {lab_wire.sym} -330 -1500 0 0 {name=p36 sig_type=std_logic lab=D1}
C {lab_wire.sym} 190 -1500 0 0 {name=p37 sig_type=std_logic lab=D1}
C {lab_wire.sym} 710 -1500 0 0 {name=p38 sig_type=std_logic lab=D1}
C {CS_Switch_16x.sym} -2030 -1650 3 0 {name=x15}
C {gnd.sym} -2020 -1440 0 0 {name=l9 lab=GND}
C {lab_wire.sym} -2040 -1440 0 0 {name=p39 sig_type=std_logic lab=VBIAS}
C {CS_Switch_16x.sym} -1530 -1650 3 0 {name=x16}
C {gnd.sym} -1520 -1440 0 0 {name=l10 lab=GND}
C {lab_wire.sym} -1540 -1440 0 0 {name=p40 sig_type=std_logic lab=VBIAS}
C {CS_Switch_16x.sym} -1040 -1650 3 0 {name=x17}
C {gnd.sym} -1030 -1440 0 0 {name=l11 lab=GND}
C {lab_wire.sym} -1050 -1440 0 0 {name=p41 sig_type=std_logic lab=VBIAS}
C {CS_Switch_16x.sym} -540 -1650 3 0 {name=x18}
C {gnd.sym} -530 -1440 0 0 {name=l12 lab=GND}
C {lab_wire.sym} -550 -1440 0 0 {name=p43 sig_type=std_logic lab=VBIAS}
C {CS_Switch_16x.sym} -20 -1650 3 0 {name=x19}
C {gnd.sym} -10 -1440 0 0 {name=l13 lab=GND}
C {lab_wire.sym} -30 -1440 0 0 {name=p44 sig_type=std_logic lab=VBIAS}
C {CS_Switch_16x.sym} 500 -1650 3 0 {name=x20}
C {gnd.sym} 510 -1440 0 0 {name=l14 lab=GND}
C {lab_wire.sym} 490 -1440 0 0 {name=p45 sig_type=std_logic lab=VBIAS}
C {CS_Switch_16x.sym} 1020 -1650 3 0 {name=x21}
C {gnd.sym} 1030 -1440 0 0 {name=l15 lab=GND}
C {lab_wire.sym} 1010 -1440 0 0 {name=p46 sig_type=std_logic lab=VBIAS}
C {Local_encoder.sym} 1270 -1470 0 0 {name=x22}
C {lab_wire.sym} 1170 -1480 3 1 {name=p47 sig_type=std_logic lab=D2}
C {gnd.sym} 1190 -1460 1 0 {name=l16 lab=GND}
C {lab_wire.sym} 1210 -1440 3 0 {name=p48 sig_type=std_logic lab=CLK}
C {lab_wire.sym} 1210 -1500 0 0 {name=p49 sig_type=std_logic lab=D1}
C {CS_Switch_16x.sym} 1520 -1650 3 0 {name=x23}
C {gnd.sym} 1530 -1440 0 0 {name=l17 lab=GND}
C {lab_wire.sym} 1510 -1440 0 0 {name=p50 sig_type=std_logic lab=VBIAS}
C {Local_encoder.sym} -2290 -860 0 0 {name=x24}
C {Local_encoder.sym} -1780 -860 0 0 {name=x25}
C {Local_encoder.sym} -1290 -860 0 0 {name=x26}
C {Local_encoder.sym} -790 -860 0 0 {name=x27}
C {Local_encoder.sym} -270 -860 0 0 {name=x28}
C {Local_encoder.sym} 250 -860 0 0 {name=x29}
C {Local_encoder.sym} 770 -860 0 0 {name=x30}
C {lab_wire.sym} -2350 -830 3 0 {name=p51 sig_type=std_logic lab=CLK}
C {lab_wire.sym} -2450 -870 3 1 {name=p52 sig_type=std_logic lab=D3}
C {lab_wire.sym} -1910 -870 3 1 {name=p53 sig_type=std_logic lab=D3}
C {lab_wire.sym} -1380 -870 3 1 {name=p54 sig_type=std_logic lab=D3}
C {lab_wire.sym} -910 -870 3 1 {name=p55 sig_type=std_logic lab=D3}
C {lab_wire.sym} -380 -870 3 1 {name=p56 sig_type=std_logic lab=D3}
C {lab_wire.sym} 150 -870 3 1 {name=p57 sig_type=std_logic lab=D3}
C {lab_wire.sym} 670 -870 3 1 {name=p58 sig_type=std_logic lab=D3}
C {lab_wire.sym} -2450 -850 2 1 {name=p59 sig_type=std_logic lab=C1}
C {lab_wire.sym} -1900 -850 2 1 {name=p60 sig_type=std_logic lab=C2}
C {lab_wire.sym} -1380 -850 2 1 {name=p61 sig_type=std_logic lab=C3}
C {lab_wire.sym} -900 -850 2 1 {name=p62 sig_type=std_logic lab=C4}
C {lab_wire.sym} -370 -850 2 1 {name=p63 sig_type=std_logic lab=C5}
C {lab_wire.sym} 160 -850 2 1 {name=p64 sig_type=std_logic lab=C6}
C {lab_wire.sym} 680 -850 2 1 {name=p65 sig_type=std_logic lab=C7}
C {lab_wire.sym} -1840 -830 3 0 {name=p66 sig_type=std_logic lab=CLK}
C {lab_wire.sym} -1350 -830 3 0 {name=p67 sig_type=std_logic lab=CLK}
C {lab_wire.sym} -850 -830 3 0 {name=p68 sig_type=std_logic lab=CLK}
C {lab_wire.sym} -330 -830 3 0 {name=p69 sig_type=std_logic lab=CLK}
C {lab_wire.sym} 190 -830 3 0 {name=p70 sig_type=std_logic lab=CLK}
C {lab_wire.sym} 710 -830 3 0 {name=p71 sig_type=std_logic lab=CLK}
C {lab_wire.sym} -2350 -890 0 0 {name=p72 sig_type=std_logic lab=D2}
C {lab_wire.sym} -1840 -890 0 0 {name=p73 sig_type=std_logic lab=D2}
C {lab_wire.sym} -1350 -890 0 0 {name=p74 sig_type=std_logic lab=D2}
C {lab_wire.sym} -850 -890 0 0 {name=p75 sig_type=std_logic lab=D2}
C {lab_wire.sym} -330 -890 0 0 {name=p76 sig_type=std_logic lab=D2}
C {lab_wire.sym} 190 -890 0 0 {name=p77 sig_type=std_logic lab=D2}
C {lab_wire.sym} 710 -890 0 0 {name=p78 sig_type=std_logic lab=D2}
C {CS_Switch_16x.sym} -2030 -1040 3 0 {name=x31}
C {gnd.sym} -2020 -830 0 0 {name=l18 lab=GND}
C {lab_wire.sym} -2040 -830 0 0 {name=p79 sig_type=std_logic lab=VBIAS}
C {CS_Switch_16x.sym} -1530 -1040 3 0 {name=x32}
C {gnd.sym} -1520 -830 0 0 {name=l19 lab=GND}
C {lab_wire.sym} -1540 -830 0 0 {name=p80 sig_type=std_logic lab=VBIAS}
C {CS_Switch_16x.sym} -1040 -1040 3 0 {name=x33}
C {gnd.sym} -1030 -830 0 0 {name=l20 lab=GND}
C {lab_wire.sym} -1050 -830 0 0 {name=p81 sig_type=std_logic lab=VBIAS}
C {CS_Switch_16x.sym} -540 -1040 3 0 {name=x34}
C {gnd.sym} -530 -830 0 0 {name=l21 lab=GND}
C {lab_wire.sym} -550 -830 0 0 {name=p82 sig_type=std_logic lab=VBIAS}
C {CS_Switch_16x.sym} -20 -1040 3 0 {name=x35}
C {gnd.sym} -10 -830 0 0 {name=l22 lab=GND}
C {lab_wire.sym} -30 -830 0 0 {name=p83 sig_type=std_logic lab=VBIAS}
C {CS_Switch_16x.sym} 500 -1040 3 0 {name=x36}
C {gnd.sym} 510 -830 0 0 {name=l23 lab=GND}
C {lab_wire.sym} 490 -830 0 0 {name=p84 sig_type=std_logic lab=VBIAS}
C {CS_Switch_16x.sym} 1020 -1040 3 0 {name=x37}
C {gnd.sym} 1030 -830 0 0 {name=l24 lab=GND}
C {lab_wire.sym} 1010 -830 0 0 {name=p85 sig_type=std_logic lab=VBIAS}
C {Local_encoder.sym} 1270 -860 0 0 {name=x38}
C {lab_wire.sym} 1170 -870 3 1 {name=p86 sig_type=std_logic lab=D3}
C {gnd.sym} 1190 -850 1 0 {name=l25 lab=GND}
C {lab_wire.sym} 1210 -830 3 0 {name=p87 sig_type=std_logic lab=CLK}
C {lab_wire.sym} 1210 -890 0 0 {name=p88 sig_type=std_logic lab=D1}
C {CS_Switch_16x.sym} 1520 -1040 3 0 {name=x39}
C {gnd.sym} 1530 -830 0 0 {name=l26 lab=GND}
C {lab_wire.sym} 1510 -830 0 0 {name=p89 sig_type=std_logic lab=VBIAS}
C {Local_encoder.sym} -2290 -240 0 0 {name=x40}
C {Local_encoder.sym} -1780 -240 0 0 {name=x41}
C {Local_encoder.sym} -1290 -240 0 0 {name=x42}
C {Local_encoder.sym} -790 -240 0 0 {name=x43}
C {Local_encoder.sym} -270 -240 0 0 {name=x44}
C {Local_encoder.sym} 250 -240 0 0 {name=x45}
C {Local_encoder.sym} 770 -240 0 0 {name=x46}
C {lab_wire.sym} -2350 -210 3 0 {name=p90 sig_type=std_logic lab=CLK}
C {lab_wire.sym} -2450 -250 3 1 {name=p91 sig_type=std_logic lab=D4}
C {lab_wire.sym} -1910 -250 3 1 {name=p92 sig_type=std_logic lab=D4}
C {lab_wire.sym} -1380 -250 3 1 {name=p93 sig_type=std_logic lab=D4}
C {lab_wire.sym} -910 -250 3 1 {name=p94 sig_type=std_logic lab=D4}
C {lab_wire.sym} -380 -250 3 1 {name=p95 sig_type=std_logic lab=D4}
C {lab_wire.sym} 150 -250 3 1 {name=p96 sig_type=std_logic lab=D4}
C {lab_wire.sym} 670 -250 3 1 {name=p97 sig_type=std_logic lab=D4}
C {lab_wire.sym} -2450 -230 2 1 {name=p98 sig_type=std_logic lab=C1}
C {lab_wire.sym} -1900 -230 2 1 {name=p99 sig_type=std_logic lab=C2}
C {lab_wire.sym} -1380 -230 2 1 {name=p100 sig_type=std_logic lab=C3}
C {lab_wire.sym} -900 -230 2 1 {name=p101 sig_type=std_logic lab=C4}
C {lab_wire.sym} -370 -230 2 1 {name=p102 sig_type=std_logic lab=C5}
C {lab_wire.sym} 160 -230 2 1 {name=p103 sig_type=std_logic lab=C6}
C {lab_wire.sym} 680 -230 2 1 {name=p104 sig_type=std_logic lab=C7}
C {lab_wire.sym} -1840 -210 3 0 {name=p105 sig_type=std_logic lab=CLK}
C {lab_wire.sym} -1350 -210 3 0 {name=p106 sig_type=std_logic lab=CLK}
C {lab_wire.sym} -850 -210 3 0 {name=p107 sig_type=std_logic lab=CLK}
C {lab_wire.sym} -330 -210 3 0 {name=p108 sig_type=std_logic lab=CLK}
C {lab_wire.sym} 190 -210 3 0 {name=p109 sig_type=std_logic lab=CLK}
C {lab_wire.sym} 710 -210 3 0 {name=p110 sig_type=std_logic lab=CLK}
C {lab_wire.sym} -2350 -270 0 0 {name=p111 sig_type=std_logic lab=D3}
C {lab_wire.sym} -1840 -270 0 0 {name=p112 sig_type=std_logic lab=D3}
C {lab_wire.sym} -1350 -270 0 0 {name=p113 sig_type=std_logic lab=D3}
C {lab_wire.sym} -850 -270 0 0 {name=p114 sig_type=std_logic lab=D3}
C {lab_wire.sym} -330 -270 0 0 {name=p115 sig_type=std_logic lab=D3}
C {lab_wire.sym} 190 -270 0 0 {name=p116 sig_type=std_logic lab=D3}
C {lab_wire.sym} 710 -270 0 0 {name=p117 sig_type=std_logic lab=D3}
C {CS_Switch_16x.sym} -2030 -420 3 0 {name=x47}
C {gnd.sym} -2020 -210 0 0 {name=l28 lab=GND}
C {lab_wire.sym} -2040 -210 0 0 {name=p118 sig_type=std_logic lab=VBIAS}
C {CS_Switch_16x.sym} -1530 -420 3 0 {name=x48}
C {gnd.sym} -1520 -210 0 0 {name=l29 lab=GND}
C {lab_wire.sym} -1540 -210 0 0 {name=p119 sig_type=std_logic lab=VBIAS}
C {CS_Switch_16x.sym} -1040 -420 3 0 {name=x49}
C {gnd.sym} -1030 -210 0 0 {name=l30 lab=GND}
C {lab_wire.sym} -1050 -210 0 0 {name=p120 sig_type=std_logic lab=VBIAS}
C {CS_Switch_16x.sym} -540 -420 3 0 {name=x50}
C {gnd.sym} -530 -210 0 0 {name=l31 lab=GND}
C {lab_wire.sym} -550 -210 0 0 {name=p121 sig_type=std_logic lab=VBIAS}
C {CS_Switch_16x.sym} -20 -420 3 0 {name=x51}
C {gnd.sym} -10 -210 0 0 {name=l32 lab=GND}
C {lab_wire.sym} -30 -210 0 0 {name=p122 sig_type=std_logic lab=VBIAS}
C {CS_Switch_16x.sym} 500 -420 3 0 {name=x52}
C {gnd.sym} 510 -210 0 0 {name=l33 lab=GND}
C {lab_wire.sym} 490 -210 0 0 {name=p123 sig_type=std_logic lab=VBIAS}
C {CS_Switch_16x.sym} 1020 -420 3 0 {name=x53}
C {gnd.sym} 1030 -210 0 0 {name=l34 lab=GND}
C {lab_wire.sym} 1010 -210 0 0 {name=p124 sig_type=std_logic lab=VBIAS}
C {Local_encoder.sym} 1270 -240 0 0 {name=x54}
C {lab_wire.sym} 1170 -250 3 1 {name=p125 sig_type=std_logic lab=D4}
C {gnd.sym} 1190 -230 1 0 {name=l35 lab=GND}
C {lab_wire.sym} 1210 -210 3 0 {name=p126 sig_type=std_logic lab=CLK}
C {lab_wire.sym} 1210 -270 0 0 {name=p135 sig_type=std_logic lab=D3}
C {CS_Switch_16x.sym} 1520 -420 3 0 {name=x55}
C {gnd.sym} 1530 -210 0 0 {name=l36 lab=GND}
C {lab_wire.sym} 1510 -210 0 0 {name=p141 sig_type=std_logic lab=VBIAS}
C {Local_encoder.sym} -2290 320 0 0 {name=x56}
C {Local_encoder.sym} -1780 320 0 0 {name=x57}
C {Local_encoder.sym} -1290 320 0 0 {name=x58}
C {Local_encoder.sym} -790 320 0 0 {name=x59}
C {Local_encoder.sym} -270 320 0 0 {name=x60}
C {Local_encoder.sym} 250 320 0 0 {name=x61}
C {Local_encoder.sym} 770 320 0 0 {name=x62}
C {lab_wire.sym} -2350 350 3 0 {name=p142 sig_type=std_logic lab=CLK}
C {lab_wire.sym} -2450 310 3 1 {name=p143 sig_type=std_logic lab=D5}
C {lab_wire.sym} -1910 310 3 1 {name=p151 sig_type=std_logic lab=D5}
C {lab_wire.sym} -1380 310 3 1 {name=p159 sig_type=std_logic lab=D5}
C {lab_wire.sym} -910 310 3 1 {name=p170 sig_type=std_logic lab=D5}
C {lab_wire.sym} -380 310 3 1 {name=p178 sig_type=std_logic lab=D5}
C {lab_wire.sym} 150 310 3 1 {name=p179 sig_type=std_logic lab=D5}
C {lab_wire.sym} 670 310 3 1 {name=p180 sig_type=std_logic lab=D5}
C {lab_wire.sym} -2450 330 2 1 {name=p181 sig_type=std_logic lab=C1}
C {lab_wire.sym} -1900 330 2 1 {name=p182 sig_type=std_logic lab=C2}
C {lab_wire.sym} -1380 330 2 1 {name=p183 sig_type=std_logic lab=C3}
C {lab_wire.sym} -900 330 2 1 {name=p184 sig_type=std_logic lab=C4}
C {lab_wire.sym} -370 330 2 1 {name=p185 sig_type=std_logic lab=C5}
C {lab_wire.sym} 160 330 2 1 {name=p186 sig_type=std_logic lab=C6}
C {lab_wire.sym} 680 330 2 1 {name=p187 sig_type=std_logic lab=C7}
C {lab_wire.sym} -1840 350 3 0 {name=p188 sig_type=std_logic lab=CLK}
C {lab_wire.sym} -1350 350 3 0 {name=p189 sig_type=std_logic lab=CLK}
C {lab_wire.sym} -850 350 3 0 {name=p190 sig_type=std_logic lab=CLK}
C {lab_wire.sym} -330 350 3 0 {name=p191 sig_type=std_logic lab=CLK}
C {lab_wire.sym} 190 350 3 0 {name=p192 sig_type=std_logic lab=CLK}
C {lab_wire.sym} 710 350 3 0 {name=p193 sig_type=std_logic lab=CLK}
C {lab_wire.sym} -2350 290 0 0 {name=p194 sig_type=std_logic lab=D4}
C {lab_wire.sym} -1840 290 0 0 {name=p195 sig_type=std_logic lab=D4}
C {lab_wire.sym} -1350 290 0 0 {name=p196 sig_type=std_logic lab=D4}
C {lab_wire.sym} -850 290 0 0 {name=p197 sig_type=std_logic lab=D4}
C {lab_wire.sym} -330 290 0 0 {name=p198 sig_type=std_logic lab=D4}
C {lab_wire.sym} 190 290 0 0 {name=p199 sig_type=std_logic lab=D4}
C {lab_wire.sym} 710 290 0 0 {name=p200 sig_type=std_logic lab=D4}
C {CS_Switch_16x.sym} -2030 140 3 0 {name=x63}
C {gnd.sym} -2020 350 0 0 {name=l37 lab=GND}
C {lab_wire.sym} -2040 350 0 0 {name=p201 sig_type=std_logic lab=VBIAS}
C {CS_Switch_16x.sym} -1530 140 3 0 {name=x87}
C {gnd.sym} -1520 350 0 0 {name=l38 lab=GND}
C {lab_wire.sym} -1540 350 0 0 {name=p202 sig_type=std_logic lab=VBIAS}
C {CS_Switch_16x.sym} -1040 140 3 0 {name=x88}
C {gnd.sym} -1030 350 0 0 {name=l39 lab=GND}
C {lab_wire.sym} -1050 350 0 0 {name=p203 sig_type=std_logic lab=VBIAS}
C {CS_Switch_16x.sym} -540 140 3 0 {name=x89}
C {gnd.sym} -530 350 0 0 {name=l40 lab=GND}
C {lab_wire.sym} -550 350 0 0 {name=p204 sig_type=std_logic lab=VBIAS}
C {CS_Switch_16x.sym} -20 140 3 0 {name=x90}
C {gnd.sym} -10 350 0 0 {name=l41 lab=GND}
C {lab_wire.sym} -30 350 0 0 {name=p205 sig_type=std_logic lab=VBIAS}
C {CS_Switch_16x.sym} 500 140 3 0 {name=x91}
C {gnd.sym} 510 350 0 0 {name=l42 lab=GND}
C {lab_wire.sym} 490 350 0 0 {name=p206 sig_type=std_logic lab=VBIAS}
C {CS_Switch_16x.sym} 1020 140 3 0 {name=x92}
C {gnd.sym} 1030 350 0 0 {name=l43 lab=GND}
C {lab_wire.sym} 1010 350 0 0 {name=p207 sig_type=std_logic lab=VBIAS}
C {Local_encoder.sym} 1270 320 0 0 {name=x93}
C {lab_wire.sym} 1170 310 3 1 {name=p208 sig_type=std_logic lab=D5}
C {gnd.sym} 1190 330 1 0 {name=l44 lab=GND}
C {lab_wire.sym} 1210 350 3 0 {name=p209 sig_type=std_logic lab=CLK}
C {lab_wire.sym} 1210 290 0 0 {name=p210 sig_type=std_logic lab=D4}
C {CS_Switch_16x.sym} 1520 140 3 0 {name=x94}
C {gnd.sym} 1530 350 0 0 {name=l45 lab=GND}
C {lab_wire.sym} 1510 350 0 0 {name=p211 sig_type=std_logic lab=VBIAS}
C {Local_encoder.sym} -2290 860 0 0 {name=x95}
C {Local_encoder.sym} -1780 860 0 0 {name=x96}
C {Local_encoder.sym} -1290 860 0 0 {name=x97}
C {Local_encoder.sym} -790 860 0 0 {name=x98}
C {Local_encoder.sym} -270 860 0 0 {name=x99}
C {Local_encoder.sym} 250 860 0 0 {name=x100}
C {Local_encoder.sym} 770 860 0 0 {name=x101}
C {lab_wire.sym} -2350 890 3 0 {name=p212 sig_type=std_logic lab=CLK}
C {lab_wire.sym} -2450 850 3 1 {name=p213 sig_type=std_logic lab=D6}
C {lab_wire.sym} -910 850 3 1 {name=p216 sig_type=std_logic lab=D6}
C {lab_wire.sym} -380 850 3 1 {name=p217 sig_type=std_logic lab=D6}
C {lab_wire.sym} 150 850 3 1 {name=p218 sig_type=std_logic lab=D6}
C {lab_wire.sym} 670 850 3 1 {name=p219 sig_type=std_logic lab=D6}
C {lab_wire.sym} -2450 870 2 1 {name=p220 sig_type=std_logic lab=C1}
C {lab_wire.sym} -1900 870 2 1 {name=p221 sig_type=std_logic lab=C2}
C {lab_wire.sym} -1380 870 2 1 {name=p222 sig_type=std_logic lab=C3}
C {lab_wire.sym} -900 870 2 1 {name=p223 sig_type=std_logic lab=C4}
C {lab_wire.sym} -370 870 2 1 {name=p224 sig_type=std_logic lab=C5}
C {lab_wire.sym} 160 870 2 1 {name=p225 sig_type=std_logic lab=C6}
C {lab_wire.sym} 680 870 2 1 {name=p226 sig_type=std_logic lab=C7}
C {lab_wire.sym} -1840 890 3 0 {name=p227 sig_type=std_logic lab=CLK}
C {lab_wire.sym} -1350 890 3 0 {name=p228 sig_type=std_logic lab=CLK}
C {lab_wire.sym} -850 890 3 0 {name=p229 sig_type=std_logic lab=CLK}
C {lab_wire.sym} -330 890 3 0 {name=p230 sig_type=std_logic lab=CLK}
C {lab_wire.sym} 190 890 3 0 {name=p231 sig_type=std_logic lab=CLK}
C {lab_wire.sym} 710 890 3 0 {name=p232 sig_type=std_logic lab=CLK}
C {lab_wire.sym} -2350 830 0 0 {name=p233 sig_type=std_logic lab=D5}
C {lab_wire.sym} -850 830 0 0 {name=p236 sig_type=std_logic lab=D5}
C {lab_wire.sym} -330 830 0 0 {name=p237 sig_type=std_logic lab=D5}
C {lab_wire.sym} 190 830 0 0 {name=p238 sig_type=std_logic lab=D5}
C {lab_wire.sym} 710 830 0 0 {name=p239 sig_type=std_logic lab=D5}
C {CS_Switch_16x.sym} -2030 680 3 0 {name=x102}
C {gnd.sym} -2020 890 0 0 {name=l46 lab=GND}
C {lab_wire.sym} -2040 890 0 0 {name=p240 sig_type=std_logic lab=VBIAS}
C {CS_Switch_16x.sym} -1530 680 3 0 {name=x103}
C {gnd.sym} -1520 890 0 0 {name=l47 lab=GND}
C {lab_wire.sym} -1540 890 0 0 {name=p241 sig_type=std_logic lab=VBIAS}
C {CS_Switch_16x.sym} -1040 680 3 0 {name=x104}
C {gnd.sym} -1030 890 0 0 {name=l48 lab=GND}
C {lab_wire.sym} -1050 890 0 0 {name=p242 sig_type=std_logic lab=VBIAS}
C {CS_Switch_16x.sym} -540 680 3 0 {name=x105}
C {gnd.sym} -530 890 0 0 {name=l49 lab=GND}
C {lab_wire.sym} -550 890 0 0 {name=p243 sig_type=std_logic lab=VBIAS}
C {CS_Switch_16x.sym} -20 680 3 0 {name=x106}
C {gnd.sym} -10 890 0 0 {name=l50 lab=GND}
C {lab_wire.sym} -30 890 0 0 {name=p244 sig_type=std_logic lab=VBIAS}
C {CS_Switch_16x.sym} 500 680 3 0 {name=x107}
C {gnd.sym} 510 890 0 0 {name=l51 lab=GND}
C {lab_wire.sym} 490 890 0 0 {name=p245 sig_type=std_logic lab=VBIAS}
C {CS_Switch_16x.sym} 1020 680 3 0 {name=x108}
C {gnd.sym} 1030 890 0 0 {name=l52 lab=GND}
C {lab_wire.sym} 1010 890 0 0 {name=p246 sig_type=std_logic lab=VBIAS}
C {Local_encoder.sym} 1270 860 0 0 {name=x109}
C {lab_wire.sym} 1170 850 3 1 {name=p247 sig_type=std_logic lab=D6}
C {gnd.sym} 1190 870 1 0 {name=l53 lab=GND}
C {lab_wire.sym} 1210 890 3 0 {name=p248 sig_type=std_logic lab=CLK}
C {lab_wire.sym} 1210 830 0 0 {name=p249 sig_type=std_logic lab=D5}
C {CS_Switch_16x.sym} 1520 680 3 0 {name=x110}
C {gnd.sym} 1530 890 0 0 {name=l54 lab=GND}
C {lab_wire.sym} 1510 890 0 0 {name=p250 sig_type=std_logic lab=VBIAS}
C {Local_encoder.sym} -2290 1440 0 0 {name=x111}
C {Local_encoder.sym} -1780 1440 0 0 {name=x112}
C {Local_encoder.sym} -1290 1440 0 0 {name=x113}
C {Local_encoder.sym} -790 1440 0 0 {name=x114}
C {Local_encoder.sym} -270 1440 0 0 {name=x115}
C {Local_encoder.sym} 250 1440 0 0 {name=x116}
C {Local_encoder.sym} 770 1440 0 0 {name=x117}
C {lab_wire.sym} -2350 1470 3 0 {name=p251 sig_type=std_logic lab=CLK}
C {lab_wire.sym} -2450 1430 3 1 {name=p252 sig_type=std_logic lab=D7}
C {lab_wire.sym} -1910 1430 3 1 {name=p253 sig_type=std_logic lab=D7}
C {lab_wire.sym} -1380 1430 3 1 {name=p254 sig_type=std_logic lab=D7}
C {lab_wire.sym} -910 1430 3 1 {name=p255 sig_type=std_logic lab=D7}
C {lab_wire.sym} -380 1430 3 1 {name=p256 sig_type=std_logic lab=D7}
C {lab_wire.sym} 150 1430 3 1 {name=p257 sig_type=std_logic lab=D7}
C {lab_wire.sym} 670 1430 3 1 {name=p258 sig_type=std_logic lab=D7}
C {lab_wire.sym} -2450 1450 2 1 {name=p259 sig_type=std_logic lab=C1}
C {lab_wire.sym} -1900 1450 2 1 {name=p260 sig_type=std_logic lab=C2}
C {lab_wire.sym} -1380 1450 2 1 {name=p261 sig_type=std_logic lab=C3}
C {lab_wire.sym} -900 1450 2 1 {name=p262 sig_type=std_logic lab=C4}
C {lab_wire.sym} -370 1450 2 1 {name=p263 sig_type=std_logic lab=C5}
C {lab_wire.sym} 160 1450 2 1 {name=p264 sig_type=std_logic lab=C6}
C {lab_wire.sym} 680 1450 2 1 {name=p265 sig_type=std_logic lab=C7}
C {lab_wire.sym} -1840 1470 3 0 {name=p266 sig_type=std_logic lab=CLK}
C {lab_wire.sym} -1350 1470 3 0 {name=p267 sig_type=std_logic lab=CLK}
C {lab_wire.sym} -850 1470 3 0 {name=p268 sig_type=std_logic lab=CLK}
C {lab_wire.sym} -330 1470 3 0 {name=p269 sig_type=std_logic lab=CLK}
C {lab_wire.sym} 190 1470 3 0 {name=p270 sig_type=std_logic lab=CLK}
C {lab_wire.sym} 710 1470 3 0 {name=p271 sig_type=std_logic lab=CLK}
C {lab_wire.sym} -2350 1410 0 0 {name=p272 sig_type=std_logic lab=D6}
C {lab_wire.sym} -1840 1410 0 0 {name=p273 sig_type=std_logic lab=D6}
C {lab_wire.sym} -1350 1410 0 0 {name=p274 sig_type=std_logic lab=D6}
C {lab_wire.sym} -850 1410 0 0 {name=p275 sig_type=std_logic lab=D6}
C {lab_wire.sym} -330 1410 0 0 {name=p276 sig_type=std_logic lab=D6}
C {lab_wire.sym} 190 1410 0 0 {name=p277 sig_type=std_logic lab=D6}
C {lab_wire.sym} 710 1410 0 0 {name=p278 sig_type=std_logic lab=D6}
C {CS_Switch_16x.sym} -2030 1260 3 0 {name=x118}
C {gnd.sym} -2020 1470 0 0 {name=l55 lab=GND}
C {lab_wire.sym} -2040 1470 0 0 {name=p279 sig_type=std_logic lab=VBIAS}
C {CS_Switch_16x.sym} -1530 1260 3 0 {name=x119}
C {gnd.sym} -1520 1470 0 0 {name=l56 lab=GND}
C {lab_wire.sym} -1540 1470 0 0 {name=p280 sig_type=std_logic lab=VBIAS}
C {CS_Switch_16x.sym} -1040 1260 3 0 {name=x120}
C {gnd.sym} -1030 1470 0 0 {name=l57 lab=GND}
C {lab_wire.sym} -1050 1470 0 0 {name=p281 sig_type=std_logic lab=VBIAS}
C {CS_Switch_16x.sym} -540 1260 3 0 {name=x121}
C {gnd.sym} -530 1470 0 0 {name=l58 lab=GND}
C {lab_wire.sym} -550 1470 0 0 {name=p282 sig_type=std_logic lab=VBIAS}
C {CS_Switch_16x.sym} -20 1260 3 0 {name=x122}
C {gnd.sym} -10 1470 0 0 {name=l59 lab=GND}
C {lab_wire.sym} -30 1470 0 0 {name=p283 sig_type=std_logic lab=VBIAS}
C {CS_Switch_16x.sym} 500 1260 3 0 {name=x123}
C {gnd.sym} 510 1470 0 0 {name=l60 lab=GND}
C {lab_wire.sym} 490 1470 0 0 {name=p284 sig_type=std_logic lab=VBIAS}
C {CS_Switch_16x.sym} 1020 1260 3 0 {name=x124}
C {gnd.sym} 1030 1470 0 0 {name=l61 lab=GND}
C {lab_wire.sym} 1010 1470 0 0 {name=p285 sig_type=std_logic lab=VBIAS}
C {Local_encoder.sym} 1270 1440 0 0 {name=x125}
C {lab_wire.sym} 1170 1430 3 1 {name=p286 sig_type=std_logic lab=D7}
C {gnd.sym} 1190 1450 1 0 {name=l62 lab=GND}
C {lab_wire.sym} 1210 1470 3 0 {name=p287 sig_type=std_logic lab=CLK}
C {lab_wire.sym} 1210 1410 0 0 {name=p288 sig_type=std_logic lab=D6}
C {CS_Switch_16x.sym} 1520 1260 3 0 {name=x126}
C {gnd.sym} 1530 1470 0 0 {name=l63 lab=GND}
C {lab_wire.sym} 1510 1470 0 0 {name=p289 sig_type=std_logic lab=VBIAS}
C {Local_encoder.sym} -2290 2040 0 0 {name=x127}
C {Local_encoder.sym} -1780 2040 0 0 {name=x128}
C {Local_encoder.sym} -1290 2040 0 0 {name=x129}
C {Local_encoder.sym} -790 2040 0 0 {name=x130}
C {Local_encoder.sym} -270 2040 0 0 {name=x131}
C {Local_encoder.sym} 250 2040 0 0 {name=x132}
C {Local_encoder.sym} 770 2040 0 0 {name=x133}
C {lab_wire.sym} -2350 2070 3 0 {name=p290 sig_type=std_logic lab=CLK}
C {lab_wire.sym} -2450 2050 2 1 {name=p298 sig_type=std_logic lab=C1}
C {lab_wire.sym} -1900 2050 2 1 {name=p299 sig_type=std_logic lab=C2}
C {lab_wire.sym} -1380 2050 2 1 {name=p300 sig_type=std_logic lab=C3}
C {lab_wire.sym} -900 2050 2 1 {name=p301 sig_type=std_logic lab=C4}
C {lab_wire.sym} -370 2050 2 1 {name=p302 sig_type=std_logic lab=C5}
C {lab_wire.sym} 160 2050 2 1 {name=p303 sig_type=std_logic lab=C6}
C {lab_wire.sym} 680 2050 2 1 {name=p304 sig_type=std_logic lab=C7}
C {lab_wire.sym} -1840 2070 3 0 {name=p305 sig_type=std_logic lab=CLK}
C {lab_wire.sym} -1350 2070 3 0 {name=p306 sig_type=std_logic lab=CLK}
C {lab_wire.sym} -850 2070 3 0 {name=p307 sig_type=std_logic lab=CLK}
C {lab_wire.sym} -330 2070 3 0 {name=p308 sig_type=std_logic lab=CLK}
C {lab_wire.sym} 190 2070 3 0 {name=p309 sig_type=std_logic lab=CLK}
C {lab_wire.sym} 710 2070 3 0 {name=p310 sig_type=std_logic lab=CLK}
C {lab_wire.sym} -2350 2010 0 0 {name=p311 sig_type=std_logic lab=D7
}
C {lab_wire.sym} -1840 2010 0 0 {name=p312 sig_type=std_logic lab=D7}
C {lab_wire.sym} -1350 2010 0 0 {name=p313 sig_type=std_logic lab=D7}
C {lab_wire.sym} -850 2010 0 0 {name=p314 sig_type=std_logic lab=D7}
C {lab_wire.sym} -330 2010 0 0 {name=p315 sig_type=std_logic lab=D7}
C {lab_wire.sym} 190 2010 0 0 {name=p316 sig_type=std_logic lab=D7}
C {lab_wire.sym} 710 2010 0 0 {name=p317 sig_type=std_logic lab=D7}
C {CS_Switch_16x.sym} -2030 1860 3 0 {name=x134}
C {gnd.sym} -2020 2070 0 0 {name=l64 lab=GND}
C {lab_wire.sym} -2040 2070 0 0 {name=p318 sig_type=std_logic lab=VBIAS}
C {CS_Switch_16x.sym} -1530 1860 3 0 {name=x135}
C {gnd.sym} -1520 2070 0 0 {name=l65 lab=GND}
C {lab_wire.sym} -1540 2070 0 0 {name=p319 sig_type=std_logic lab=VBIAS}
C {CS_Switch_16x.sym} -1040 1860 3 0 {name=x136}
C {gnd.sym} -1030 2070 0 0 {name=l66 lab=GND}
C {lab_wire.sym} -1050 2070 0 0 {name=p320 sig_type=std_logic lab=VBIAS}
C {CS_Switch_16x.sym} -540 1860 3 0 {name=x137}
C {gnd.sym} -530 2070 0 0 {name=l67 lab=GND}
C {lab_wire.sym} -550 2070 0 0 {name=p321 sig_type=std_logic lab=VBIAS}
C {CS_Switch_16x.sym} -20 1860 3 0 {name=x138}
C {gnd.sym} -10 2070 0 0 {name=l68 lab=GND}
C {lab_wire.sym} -30 2070 0 0 {name=p322 sig_type=std_logic lab=VBIAS}
C {CS_Switch_16x.sym} 500 1860 3 0 {name=x139}
C {gnd.sym} 510 2070 0 0 {name=l69 lab=GND}
C {lab_wire.sym} 490 2070 0 0 {name=p323 sig_type=std_logic lab=VBIAS}
C {CS_Switch_16x.sym} 1020 1860 3 0 {name=x140}
C {gnd.sym} 1030 2070 0 0 {name=l70 lab=GND}
C {lab_wire.sym} 1010 2070 0 0 {name=p324 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} -1940 850 3 1 {name=p325 sig_type=std_logic lab=D6}
C {lab_wire.sym} -1840 830 0 0 {name=p326 sig_type=std_logic lab=D5}
C {lab_wire.sym} -1450 850 3 1 {name=p214 sig_type=std_logic lab=D6}
C {lab_wire.sym} -1350 830 0 0 {name=p234 sig_type=std_logic lab=D5}
C {gnd.sym} -2450 2030 2 0 {name=l71 lab=GND}
C {gnd.sym} -1910 2030 2 0 {name=l72 lab=GND}
C {gnd.sym} -1420 2030 2 0 {name=l73 lab=GND}
C {gnd.sym} -910 2030 2 0 {name=l74 lab=GND}
C {gnd.sym} -400 2030 2 0 {name=l75 lab=GND}
C {gnd.sym} 110 2030 2 0 {name=l76 lab=GND}
C {gnd.sym} 630 2030 2 0 {name=l77 lab=GND}
C {res.sym} 1740 -2670 0 0 {name=R1
value=50
footprint=1206
device=resistor
m=1}
C {res.sym} 1860 -2670 0 0 {name=R2
value=50
footprint=1206
device=resistor
m=1}
C {lab_wire.sym} 1740 -2780 0 0 {name=p215 sig_type=std_logic lab=VP}
C {lab_wire.sym} 1860 -2780 0 1 {name=p235 sig_type=std_logic lab=VP}
C {lab_wire.sym} 1740 -2590 0 0 {name=p291 sig_type=std_logic lab=OUT+}
C {lab_wire.sym} 1860 -2590 0 1 {name=p292 sig_type=std_logic lab=OUT-}
